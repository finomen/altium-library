*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/2.20e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF221KW31
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF221KW31 Port1 Port2
C01 Port1 N01 2.14e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 5.08e-12
R03 N02 N03 6.57e-02
C04 N03 N04 5.11e-10
L04 N03 N04 7.30e-11
R04 N03 N04 4.03e+00
C05 N04 N05 1.51e-10
L05 N04 N05 7.67e-11
R05 N04 N05 5.06e+00
C06 N05 Port2 1.32e-12
L06 N05 Port2 9.85e-10
R06 N05 Port2 3.46e+02
.ENDS GA352QR7GF221KW31

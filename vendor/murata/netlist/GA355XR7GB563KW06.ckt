*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/5.60e-02[uF]/250[Vac]
* Murata P/N :GA355XR7GB563KW06
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355XR7GB563KW06 Port1 Port2
C01 Port1 N01 5.65e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.27e-10
R03 N02 N03 2.48e-05
C04 N03 N04 2.88e-06
R04 N03 N04 1.39e+00
C05 N04 N05 6.14e-06
R05 N04 N05 6.52e-02
C06 N05 N06 4.94e-06
R06 N05 N06 1.98e-02
C07 N06 N07 5.19e-07
R07 N06 N07 1.71e-02
L08 N07 N08 3.13e-10
R08 N07 N08 1.56e-01
C09 N08 N09 1.10e-07
L09 N08 N09 1.31e-10
R09 N08 N09 2.58e-01
C10 N09 N10 6.02e-08
L10 N09 N10 7.33e-11
R10 N09 N10 1.56e-01
C11 N10 Port2 6.14e-12
L11 N10 Port2 3.36e-10
R11 N10 Port2 5.73e+01
.ENDS GA355XR7GB563KW06

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/6.80e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGD680JW31
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGD680JW31 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 2.20e-10
R03 N02 N03 1.42e-01
C04 N03 N04 1.79e-10
L04 N03 N04 3.37e-11
R04 N03 N04 2.14e+00
C05 N04 N05 1.64e-11
L05 N04 N05 1.02e-10
R05 N04 N05 1.09e+01
C06 N05 Port2 1.43e-12
L06 N05 Port2 6.19e-10
R06 N05 Port2 3.45e+02
.ENDS GA342A1XGD680JW31

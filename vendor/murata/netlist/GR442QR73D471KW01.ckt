*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/4.70e-04[uF]/2000[V]
* Murata P/N :GR442QR73D471KW01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D471KW01 Port1 Port2
C01 Port1 N01 4.66e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.22e-10
R03 N02 N03 4.19e-01
C04 N03 N04 8.38e-09
R04 N03 N04 7.22e+01
C05 N04 N05 2.02e-08
R05 N04 N05 1.79e+00
C06 N05 N06 8.20e-09
R06 N05 N06 4.59e-01
C07 N06 N07 7.11e-09
R07 N06 N07 1.85e-01
C08 N07 N08 1.61e-09
L08 N07 N08 5.93e-11
R08 N07 N08 7.01e-01
C09 N08 N09 1.31e-11
L09 N08 N09 1.48e-10
R09 N08 N09 1.57e+01
C10 N09 Port2 1.62e-12
L10 N09 Port2 6.08e-10
R10 N09 Port2 4.06e+01
.ENDS GR442QR73D471KW01

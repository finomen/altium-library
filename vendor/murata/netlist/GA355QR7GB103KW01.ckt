*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-02[uF]/250[Vac]
* Murata P/N :GA355QR7GB103KW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355QR7GB103KW01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.68e-10
R03 N02 N03 4.59e-02
C04 N03 N04 4.66e-07
R04 N03 N04 6.81e+00
C05 N04 N05 1.88e-06
R05 N04 N05 2.88e-01
C06 N05 N06 6.66e-07
R06 N05 N06 1.97e-01
C07 N06 N07 3.16e-07
R07 N06 N07 3.66e-02
L08 N07 N08 5.39e-11
R08 N07 N08 2.56e-01
C09 N08 N09 1.83e-08
L09 N08 N09 6.01e-11
R09 N08 N09 1.81e-01
C10 N09 N10 8.75e-09
L10 N09 N10 1.52e-11
R10 N09 N10 1.07e-01
C11 N10 Port2 6.93e-12
L11 N10 Port2 4.58e-10
R11 N10 Port2 4.30e+01
.ENDS GA355QR7GB103KW01

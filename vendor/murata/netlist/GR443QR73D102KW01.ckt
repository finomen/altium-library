*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.00e-03[uF]/2000[V]
* Murata P/N :GR443QR73D102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR443QR73D102KW01 Port1 Port2
C01 Port1 N01 1.04e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 4.62e-11
R03 N02 N03 1.27e-01
C04 N03 N04 1.48e-08
R04 N03 N04 1.62e+02
C05 N04 N05 1.09e-07
R05 N04 N05 1.55e+00
C06 N05 N06 9.35e-08
R06 N05 N06 5.16e-01
C07 N06 N07 6.93e-08
R07 N06 N07 2.37e-01
C08 N07 N08 5.17e-09
R08 N07 N08 2.01e-01
C09 N08 N09 2.44e-08
R09 N08 N09 1.18e-01
C10 N09 N10 2.18e-09
L10 N09 N10 2.84e-11
R10 N09 N10 2.80e-01
C11 N10 N11 1.06e-11
L11 N10 N11 3.43e-10
R11 N10 N11 1.97e+01
C12 N11 Port2 1.61e-12
L12 N11 Port2 5.75e-10
R12 N11 Port2 1.66e+01
.ENDS GR443QR73D102KW01

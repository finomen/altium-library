*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/4.70e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GF471KW01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GF471KW01 Port1 Port2
C01 Port1 N01 5.71e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.42e-10
R03 N02 N03 3.70e-01
C04 N03 N04 3.40e-09
R04 N03 N04 9.34e+02
C05 N04 N05 4.19e-08
R05 N04 N05 3.23e+00
C06 N05 N06 1.76e-07
R06 N05 N06 3.02e+00
C07 N06 N07 1.92e-08
R07 N06 N07 8.83e-01
C08 N07 N08 5.34e-09
R08 N07 N08 3.97e-01
C09 N08 N09 1.93e-09
L09 N08 N09 5.91e-11
R09 N08 N09 5.85e-01
C10 N09 N10 2.47e-10
L10 N09 N10 6.49e-11
R10 N09 N10 8.01e-01
C11 N10 Port2 2.11e-12
L11 N10 Port2 6.16e-10
R11 N10 Port2 8.61e+01
.ENDS GA342QR7GF471KW01

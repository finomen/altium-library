*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/3.30e-04[uF]/250[Vac]
* Murata P/N :GA342DR7GF331KW02
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342DR7GF331KW02 Port1 Port2
C01 Port1 N01 4.45e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 5.77e-14
R03 N02 N03 6.51e-02
C04 N03 N04 1.31e-09
R04 N03 N04 3.85e+03
C05 N04 N05 1.10e-07
R05 N04 N05 4.81e+00
C06 N05 N06 1.17e-07
R06 N05 N06 1.95e+00
C07 N06 N07 8.12e-08
R07 N06 N07 3.19e-01
C08 N07 N08 1.20e-08
R08 N07 N08 1.42e-01
L09 N08 N09 1.96e-10
R09 N08 N09 1.23e+00
C10 N09 N10 1.23e-09
L10 N09 N10 8.69e-11
R10 N09 N10 2.37e+00
C11 N10 N11 5.57e-10
L11 N10 N11 7.92e-11
R11 N10 N11 2.67e+00
C12 N11 Port2 1.16e-12
L12 N11 Port2 1.02e-09
R12 N11 Port2 2.97e+02
.ENDS GA342DR7GF331KW02

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-03[uF]/250[Vac]
* Murata P/N :GA355QR7GF222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355QR7GF222KW01 Port1 Port2
C01 Port1 N01 2.31e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 2.26e-11
R03 N02 N03 1.03e-01
C04 N03 N04 3.22e-08
R04 N03 N04 1.24e+02
C05 N04 N05 2.56e-07
R05 N04 N05 1.16e+00
C06 N05 N06 2.27e-07
R06 N05 N06 3.51e-01
C07 N06 N07 1.26e-07
R07 N06 N07 1.58e-01
C08 N07 N08 2.64e-08
R08 N07 N08 1.12e-01
L09 N08 N09 2.18e-10
R09 N08 N09 2.74e+00
C10 N09 N10 4.09e-09
L10 N09 N10 6.20e-11
R10 N09 N10 5.17e-01
C11 N10 N11 4.56e-10
L11 N10 N11 5.08e-11
R11 N10 N11 4.14e-01
C12 N11 Port2 6.29e-12
L12 N11 Port2 3.27e-10
R12 N11 Port2 4.57e+01
.ENDS GA355QR7GF222KW01

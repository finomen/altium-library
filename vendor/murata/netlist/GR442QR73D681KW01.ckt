*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/6.80e-04[uF]/2000[V]
* Murata P/N :GR442QR73D681KW01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 300[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D681KW01 Port1 Port2
C01 Port1 N01 6.70e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.38e-10
R03 N02 N03 3.43e-01
C04 N03 N04 1.56e-08
R04 N03 N04 5.77e+01
C05 N04 N05 5.30e-08
R05 N04 N05 1.90e+00
C06 N05 N06 3.25e-08
R06 N05 N06 5.37e-01
C07 N06 N07 8.89e-09
R07 N06 N07 3.94e-01
C08 N07 N08 3.20e-09
L08 N07 N08 6.14e-11
R08 N07 N08 5.40e-01
C09 N08 N09 7.37e-12
L09 N08 N09 2.78e-10
R09 N08 N09 1.97e+01
C10 N09 Port2 1.71e-12
L10 N09 Port2 4.78e-10
R10 N09 Port2 4.40e+01
.ENDS GR442QR73D681KW01

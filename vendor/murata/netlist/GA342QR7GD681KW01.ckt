*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/6.80e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD681KW01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD681KW01 Port1 Port2
C01 Port1 N01 6.91e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 5.85e-10
R03 N02 N03 3.32e-01
C04 N03 N04 7.08e-09
R04 N03 N04 4.49e+02
C05 N04 N05 1.67e-07
R05 N04 N05 1.74e+00
C06 N05 N06 3.24e-08
R06 N05 N06 1.64e+00
C07 N06 N07 8.70e-09
R07 N06 N07 4.18e-01
C08 N07 N08 4.22e-09
L08 N07 N08 5.00e-11
R08 N07 N08 4.72e-01
C09 N08 N09 6.46e-10
L09 N08 N09 2.37e-11
R09 N08 N09 4.74e-01
C10 N09 Port2 6.41e-12
L10 N09 Port2 3.21e-10
R10 N09 Port2 2.83e+01
.ENDS GA342QR7GD681KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-03[uF]/2000[V]
* Murata P/N :GR443QR73D332KW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR443QR73D332KW01 Port1 Port2
C01 Port1 N01 3.42e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 5.12e-11
R03 N02 N03 9.32e-02
C04 N03 N04 1.26e-07
R04 N03 N04 1.59e+01
C05 N04 N05 2.87e-07
R05 N04 N05 6.47e-01
C06 N05 N06 2.26e-07
R06 N05 N06 1.60e-01
C07 N06 N07 6.66e-08
R07 N06 N07 7.85e-02
L08 N07 N08 1.14e-10
R08 N07 N08 5.21e-01
C09 N08 N09 7.18e-09
L09 N08 N09 7.35e-11
R09 N08 N09 4.01e-01
C10 N09 N10 2.47e-09
L10 N09 N10 4.61e-11
R10 N09 N10 3.07e-01
C11 N10 N11 1.00e-11
L11 N10 N11 1.70e-10
R11 N10 N11 2.71e+01
C12 N11 Port2 3.25e-12
L12 N11 Port2 2.70e-10
R12 N11 Port2 3.39e+01
.ENDS GR443QR73D332KW01

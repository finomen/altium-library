*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/3.30e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGD330JW31
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGD330JW31 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 2.73e-12
R03 N02 N03 1.87e-01
C04 N03 Port2 9.68e-13
L04 N03 Port2 1.04e-09
R04 N03 Port2 6.38e+02
.ENDS GA342A1XGD330JW31

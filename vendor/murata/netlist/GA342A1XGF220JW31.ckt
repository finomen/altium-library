*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/2.20e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGF220JW31
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGF220JW31 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 2.66e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.87e-10
R04 N03 N04 5.32e+03
C05 N04 N05 5.64e-09
R05 N04 N05 2.22e-01
L06 N05 Port2 6.65e-10
R06 N05 Port2 3.36e+02
.ENDS GA342A1XGF220JW31

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.80e-03[uF]/250[Vac]
* Murata P/N :GA355QR7GF182KW01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355QR7GF182KW01 Port1 Port2
C01 Port1 N01 1.84e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 3.12e-11
R03 N02 N03 1.31e-01
C04 N03 N04 1.80e-08
R04 N03 N04 2.79e+02
C05 N04 N05 1.49e-07
R05 N04 N05 3.33e+00
C06 N05 N06 1.57e-07
R06 N05 N06 5.06e-01
C07 N06 N07 9.73e-08
R07 N06 N07 2.04e-01
C08 N07 N08 2.05e-08
R08 N07 N08 1.40e-01
L09 N08 N09 1.33e-10
R09 N08 N09 2.65e+00
C10 N09 N10 3.02e-09
L10 N09 N10 7.65e-11
R10 N09 N10 6.68e-01
C11 N10 N11 3.63e-10
L11 N10 N11 3.78e-11
R11 N10 N11 4.66e-01
C12 N11 Port2 6.35e-12
L12 N11 Port2 3.39e-10
R12 N11 Port2 3.68e+01
.ENDS GA355QR7GF182KW01

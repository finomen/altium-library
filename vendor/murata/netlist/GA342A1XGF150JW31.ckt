*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/1.50e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGF150JW31
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGF150JW31 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 3.96e-10
R03 N02 N03 2.13e-01
C04 N03 N04 1.09e-10
R04 N03 N04 7.23e+03
C05 N04 N05 1.17e-09
R05 N04 N05 1.70e+00
L06 N05 Port2 5.33e-10
R06 N05 Port2 2.69e+02
.ENDS GA342A1XGF150JW31

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GF101KW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GF101KW01 Port1 Port2
C01 Port1 N01 1.39e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.15e-10
R03 N02 N03 2.65e-01
C04 N03 N04 4.45e-10
R04 N03 N04 3.05e+03
C05 N04 N05 1.13e-08
R05 N04 N05 2.47e+01
C06 N05 N06 2.61e-08
R06 N05 N06 7.90e-01
C07 N06 N07 4.40e-09
R07 N06 N07 2.61e-01
C08 N07 N08 5.22e-10
L08 N07 N08 3.06e-11
R08 N07 N08 1.20e+00
C09 N08 N09 8.93e-11
L09 N08 N09 6.54e-11
R09 N08 N09 3.72e+00
C10 N09 Port2 1.30e-12
L10 N09 Port2 1.12e-09
R10 N09 Port2 1.95e+02
.ENDS GA342QR7GF101KW01

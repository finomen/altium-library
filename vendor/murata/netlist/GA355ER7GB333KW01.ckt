*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-02[uF]/250[Vac]
* Murata P/N :GA355ER7GB333KW01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355ER7GB333KW01 Port1 Port2
C01 Port1 N01 3.28e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.28e-10
R03 N02 N03 1.79e-02
C04 N03 N04 2.01e-06
R04 N03 N04 9.98e-01
C05 N04 N05 2.21e-06
R05 N04 N05 8.91e-02
C06 N05 N06 1.20e-06
R06 N05 N06 1.33e-02
L07 N06 N07 1.38e-10
R07 N06 N07 1.41e-01
C08 N07 N08 8.00e-08
L08 N07 N08 7.92e-11
R08 N07 N08 2.09e-01
C09 N08 N09 2.17e-08
L09 N08 N09 7.30e-11
R09 N08 N09 1.54e-01
C10 N09 Port2 6.60e-12
L10 N09 Port2 5.42e-10
R10 N09 Port2 4.44e+01
.ENDS GA355ER7GB333KW01

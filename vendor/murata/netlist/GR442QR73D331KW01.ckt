*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/3.30e-04[uF]/2000[V]
* Murata P/N :GR442QR73D331KW01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D331KW01 Port1 Port2
C01 Port1 N01 3.41e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.03e-10
R03 N02 N03 4.08e-01
C04 N03 N04 1.04e-08
R04 N03 N04 1.59e+01
C05 N04 N05 1.10e-08
R05 N04 N05 1.14e+00
C06 N05 N06 4.69e-09
R06 N05 N06 4.51e-01
C07 N06 N07 3.18e-09
R07 N06 N07 2.54e-01
C08 N07 N08 9.16e-10
L08 N07 N08 7.02e-11
R08 N07 N08 9.54e-01
C09 N08 N09 5.93e-12
L09 N08 N09 3.30e-10
R09 N08 N09 2.25e+01
C10 N09 Port2 1.22e-12
L10 N09 Port2 6.29e-10
R10 N09 Port2 3.29e+01
.ENDS GR442QR73D331KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/1.50e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF151KW31
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF151KW31 Port1 Port2
C01 Port1 N01 1.56e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 4.06e-11
R03 N02 N03 1.48e-02
L04 N03 N04 5.12e-11
R04 N03 N04 1.48e-01
C05 N04 N05 7.83e-08
L05 N04 N05 4.87e-11
R05 N04 N05 2.95e-02
C06 N05 N06 2.71e-08
L06 N05 N06 2.36e-11
R06 N05 N06 2.39e-02
C07 N06 N07 3.45e-10
L07 N06 N07 5.56e-11
R07 N06 N07 4.08e+00
C08 N07 N08 6.70e-11
L08 N07 N08 8.41e-11
R08 N07 N08 7.94e+00
C09 N08 Port2 1.97e-12
L09 N08 Port2 9.16e-10
R09 N08 Port2 2.73e+02
.ENDS GA352QR7GF151KW31

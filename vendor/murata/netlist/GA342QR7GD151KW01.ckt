*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.50e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD151KW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD151KW01 Port1 Port2
C01 Port1 N01 1.70e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.36e-10
R03 N02 N03 1.80e-01
C04 N03 N04 1.06e-09
R04 N03 N04 1.50e+03
C05 N04 N05 2.30e-08
R05 N04 N05 1.38e+01
C06 N05 N06 2.82e-08
R06 N05 N06 1.41e+00
C07 N06 N07 5.78e-09
R07 N06 N07 2.18e-01
L08 N07 N08 1.81e-10
R08 N07 N08 2.28e+00
C09 N08 N09 1.31e-09
L09 N08 N09 2.34e-11
R09 N08 N09 1.03e+00
C10 N09 N10 2.75e-10
L10 N09 N10 4.01e-11
R10 N09 N10 2.15e+00
C11 N10 Port2 1.34e-12
L11 N10 Port2 9.80e-10
R11 N10 Port2 3.13e+02
.ENDS GA342QR7GD151KW01

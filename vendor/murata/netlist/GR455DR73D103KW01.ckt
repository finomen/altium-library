*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-02[uF]/2000[V]
* Murata P/N :GR455DR73D103KW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR455DR73D103KW01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.62e-11
R03 N02 N03 4.27e-02
C04 N03 N04 6.02e-07
R04 N03 N04 3.33e+00
C05 N04 N05 9.07e-07
R05 N04 N05 2.51e-01
C06 N05 N06 8.89e-07
R06 N05 N06 5.88e-02
C07 N06 N07 3.52e-07
R07 N06 N07 2.77e-02
L08 N07 N08 9.06e-11
R08 N07 N08 2.35e-01
C09 N08 N09 1.51e-08
L09 N08 N09 7.69e-11
R09 N08 N09 2.26e-01
C10 N09 N10 8.38e-09
L10 N09 N10 4.06e-11
R10 N09 N10 2.15e-01
C11 N10 N11 8.31e-12
L11 N10 N11 4.76e-10
R11 N10 N11 4.40e+01
C12 N11 Port2 1.31e-11
L12 N11 Port2 1.73e-10
R12 N11 Port2 1.19e+01
.ENDS GR455DR73D103KW01

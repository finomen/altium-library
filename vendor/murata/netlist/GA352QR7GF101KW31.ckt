*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/1.00e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF101KW31
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF101KW31 Port1 Port2
C01 Port1 N01 9.81e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 1.24e-10
R03 N02 N03 5.51e-02
L04 N03 N04 2.44e-11
R04 N03 N04 2.21e-01
C05 N04 N05 3.57e-08
L05 N04 N05 1.02e-10
R05 N04 N05 7.10e-02
C06 N05 N06 1.20e-08
L06 N05 N06 4.17e-11
R06 N05 N06 5.25e-02
C07 N06 N07 2.38e-10
L07 N06 N07 3.56e-11
R07 N06 N07 2.98e+00
C08 N07 N08 1.65e-11
L08 N07 N08 1.53e-10
R08 N07 N08 2.72e+01
C09 N08 Port2 1.72e-12
L09 N08 Port2 9.13e-10
R09 N08 Port2 5.31e+02
.ENDS GA352QR7GF101KW31

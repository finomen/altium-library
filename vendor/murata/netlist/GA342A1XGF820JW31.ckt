*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/8.20e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGF820JW31
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGF820JW31 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 5.49e-14
R03 N02 N03 1.35e-01
C04 N03 N04 2.21e-10
L04 N03 N04 3.78e-11
R04 N03 N04 2.33e+00
C05 N04 N05 3.24e-11
L05 N04 N05 7.90e-11
R05 N04 N05 7.63e+00
C06 N05 Port2 9.89e-13
L06 N05 Port2 8.45e-10
R06 N05 Port2 3.19e+02
.ENDS GA342A1XGF820JW31

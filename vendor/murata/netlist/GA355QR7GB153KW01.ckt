*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e-02[uF]/250[Vac]
* Murata P/N :GA355QR7GB153KW01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355QR7GB153KW01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.78e-10
R03 N02 N03 3.40e-02
C04 N03 N04 6.55e-07
R04 N03 N04 4.85e+00
C05 N04 N05 9.25e-07
R05 N04 N05 2.22e-01
C06 N05 N06 5.97e-07
R06 N05 N06 3.36e-02
L07 N06 N07 9.44e-11
R07 N06 N07 3.94e-01
C08 N07 N08 2.97e-08
L08 N07 N08 6.20e-11
R08 N07 N08 1.97e-01
C09 N08 N09 9.08e-09
L09 N08 N09 3.33e-11
R09 N08 N09 1.36e-01
C10 N09 Port2 7.43e-12
L10 N09 Port2 3.18e-10
R10 N09 Port2 3.61e+01
.ENDS GA355QR7GB153KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/4.70e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF471KW01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF471KW01 Port1 Port2
C01 Port1 N01 6.08e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.89e-10
R03 N02 N03 3.70e-01
C04 N03 N04 2.03e-09
R04 N03 N04 1.97e+03
C05 N04 N05 1.07e-07
R05 N04 N05 4.95e+00
C06 N05 N06 6.36e-08
R06 N05 N06 4.17e+00
C07 N06 N07 5.22e-08
R07 N06 N07 1.02e+00
C08 N07 N08 2.19e-08
R08 N07 N08 6.87e-01
C09 N08 N09 3.72e-09
R09 N08 N09 4.41e-01
C10 N09 N10 1.17e-09
L10 N09 N10 1.23e-10
R10 N09 N10 9.63e-01
C11 N10 Port2 3.55e-12
L11 N10 Port2 5.81e-10
R11 N10 Port2 4.97e+01
.ENDS GA352QR7GF471KW01

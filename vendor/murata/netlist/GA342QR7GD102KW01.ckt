*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-03[uF]/250[Vac]
* Murata P/N :GA342QR7GD102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD102KW01 Port1 Port2
C01 Port1 N01 1.01e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 4.21e-10
R03 N02 N03 2.42e-01
C04 N03 N04 1.18e-08
R04 N03 N04 3.37e+02
C05 N04 N05 7.15e-08
R05 N04 N05 5.26e+00
C06 N05 N06 4.19e-08
R06 N05 N06 8.24e-01
C07 N06 N07 1.24e-08
R07 N06 N07 2.32e-01
C08 N07 N08 2.53e-09
L08 N07 N08 1.15e-10
R08 N07 N08 7.35e-01
C09 N08 N09 4.38e-10
L09 N08 N09 4.56e-11
R09 N08 N09 4.53e-01
C10 N09 Port2 3.89e-12
L10 N09 Port2 4.20e-10
R10 N09 Port2 4.15e+01
.ENDS GA342QR7GD102KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/6.80e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGF680JW31
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGF680JW31 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 2.78e-11
R03 N02 N03 1.23e-01
C04 N03 N04 2.01e-10
L04 N03 N04 3.06e-11
R04 N03 N04 2.39e+00
C05 N04 N05 2.14e-11
L05 N04 N05 8.01e-11
R05 N04 N05 9.46e+00
C06 N05 Port2 1.06e-12
L06 N05 Port2 8.00e-10
R06 N05 Port2 4.88e+02
.ENDS GA342A1XGF680JW31

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.50e-04[uF]/2000[V]
* Murata P/N :GR442QR73D151KW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 5[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D151KW01 Port1 Port2
C01 Port1 N01 1.51e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.73e-10
R03 N02 N03 2.18e-01
C04 N03 N04 1.18e-08
R04 N03 N04 3.29e+00
C05 N04 N05 7.91e-09
R05 N04 N05 1.73e-01
C06 N05 N06 8.86e-10
L06 N05 N06 3.42e-11
R06 N05 N06 1.27e+00
C07 N06 N07 1.25e-10
L07 N06 N07 9.33e-11
R07 N06 N07 2.96e+00
C08 N07 Port2 1.26e-12
L08 N07 Port2 1.08e-09
R08 N07 Port2 2.03e+02
.ENDS GR442QR73D151KW01

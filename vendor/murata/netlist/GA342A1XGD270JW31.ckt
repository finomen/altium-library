*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/2.70e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGD270JW31
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGD270JW31 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 4.57e-10
R03 N02 N03 1.81e-01
C04 N03 N04 4.20e-11
L04 N03 N04 6.88e-11
R04 N03 N04 1.09e+01
C05 N04 Port2 2.75e-12
L05 N04 Port2 3.89e-10
R05 N04 Port2 1.59e+02
.ENDS GA342A1XGD270JW31

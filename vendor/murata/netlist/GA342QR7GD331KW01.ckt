*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/3.30e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD331KW01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD331KW01 Port1 Port2
C01 Port1 N01 4.20e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.81e-10
R03 N02 N03 4.53e-01
C04 N03 N04 1.67e-09
R04 N03 N04 2.40e+03
C05 N04 N05 2.99e-08
R05 N04 N05 1.38e+01
C06 N05 N06 1.27e-08
R06 N05 N06 2.49e+00
C07 N06 N07 2.58e-09
R07 N06 N07 7.76e-01
C08 N07 N08 1.90e-09
L08 N07 N08 3.42e-11
R08 N07 N08 7.34e-01
C09 N08 Port2 2.55e-12
L09 N08 Port2 7.35e-10
R09 N08 Port2 3.33e+01
.ENDS GA342QR7GD331KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/SL(-55to125[deg])/5.60e-05[uF]/250[Vac]
* Murata P/N :GA342A1XGD560JW31
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342A1XGD560JW31 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 1.79e-10
R03 N02 N03 1.56e-01
C04 N03 N04 1.89e-10
L04 N03 N04 2.23e-11
R04 N03 N04 2.11e+00
C05 N04 N05 5.70e-12
L05 N04 N05 2.03e-10
R05 N04 N05 3.36e+01
C06 N05 Port2 1.34e-12
L06 N05 Port2 6.01e-10
R06 N05 Port2 2.91e+02
.ENDS GA342A1XGD560JW31

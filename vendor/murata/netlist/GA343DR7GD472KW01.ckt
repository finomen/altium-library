*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-03[uF]/250[Vac]
* Murata P/N :GA343DR7GD472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA343DR7GD472KW01 Port1 Port2
C01 Port1 N01 5.13e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 1.88e-10
R03 N02 N03 7.29e-02
C04 N03 N04 2.74e-08
R04 N03 N04 6.82e+02
C05 N04 N05 1.05e-06
R05 N04 N05 6.19e-01
C06 N05 N06 7.47e-07
R06 N05 N06 3.35e-01
C07 N06 N07 2.92e-07
R07 N06 N07 2.60e-01
C08 N07 N08 1.14e-07
R08 N07 N08 6.94e-02
L09 N08 N09 1.47e-10
R09 N08 N09 4.61e-01
C10 N09 N10 1.10e-08
L10 N09 N10 8.74e-11
R10 N09 N10 4.24e-01
C11 N10 N11 4.33e-09
L11 N10 N11 4.65e-11
R11 N10 N11 2.74e-01
C12 N11 Port2 4.22e-12
L12 N11 Port2 3.87e-10
R12 N11 Port2 3.04e+01
.ENDS GA343DR7GD472KW01

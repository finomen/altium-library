*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-03[uF]/2000[V]
* Murata P/N :GR442QR73D102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D102KW01 Port1 Port2
C01 Port1 N01 9.83e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.72e-10
R03 N02 N03 2.35e-01
C04 N03 N04 1.29e-08
R04 N03 N04 1.96e+02
C05 N04 N05 6.91e-08
R05 N04 N05 2.50e+00
C06 N05 N06 4.50e-08
R06 N05 N06 3.94e-01
C07 N06 N07 1.17e-08
R07 N06 N07 2.60e-01
C08 N07 N08 2.59e-09
L08 N07 N08 1.08e-10
R08 N07 N08 7.45e-01
C09 N08 N09 7.00e-10
L09 N08 N09 3.40e-11
R09 N08 N09 3.83e-01
C10 N09 N10 7.27e-12
L10 N09 N10 2.19e-10
R10 N09 N10 2.75e+01
C11 N10 Port2 2.24e-12
L11 N10 Port2 4.62e-10
R11 N10 Port2 4.52e+01
.ENDS GR442QR73D102KW01

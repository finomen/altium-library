*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-03[uF]/250[Vac]
* Murata P/N :GA355QR7GF332KW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355QR7GF332KW01 Port1 Port2
C01 Port1 N01 3.62e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 9.44e-11
R03 N02 N03 7.34e-02
C04 N03 N04 7.26e-08
R04 N03 N04 6.94e+01
C05 N04 N05 2.76e-07
R05 N04 N05 1.67e+00
C06 N05 N06 1.78e-07
R06 N05 N06 2.63e-01
C07 N06 N07 6.88e-08
R07 N06 N07 7.84e-02
L08 N07 N08 1.56e-10
R08 N07 N08 8.82e-01
C09 N08 N09 5.06e-09
L09 N08 N09 7.53e-11
R09 N08 N09 4.33e-01
C10 N09 N10 3.29e-09
L10 N09 N10 3.05e-11
R10 N09 N10 2.77e-01
C11 N10 Port2 6.40e-12
L11 N10 Port2 3.21e-10
R11 N10 Port2 4.49e+01
.ENDS GA355QR7GF332KW01

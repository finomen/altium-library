*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/6.80e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GF681KW01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GF681KW01 Port1 Port2
C01 Port1 N01 7.44e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.40e-10
R03 N02 N03 2.79e-01
C04 N03 N04 7.30e-09
R04 N03 N04 4.35e+02
C05 N04 N05 9.58e-08
R05 N04 N05 8.31e+00
C06 N05 N06 7.78e-08
R06 N05 N06 2.56e+00
C07 N06 N07 2.39e-08
R07 N06 N07 1.03e+00
C08 N07 N08 5.47e-09
R08 N07 N08 3.66e-01
L09 N08 N09 1.72e-10
R09 N08 N09 2.16e+00
C10 N09 N10 2.86e-09
L10 N09 N10 4.88e-11
R10 N09 N10 5.67e-01
C11 N10 N11 4.40e-10
L11 N10 N11 7.27e-11
R11 N10 N11 6.35e-01
C12 N11 Port2 2.42e-12
L12 N11 Port2 5.37e-10
R12 N11 Port2 9.45e+01
.ENDS GA342QR7GF681KW01

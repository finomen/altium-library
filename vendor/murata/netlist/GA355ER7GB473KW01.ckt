*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-02[uF]/250[Vac]
* Murata P/N :GA355ER7GB473KW01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355ER7GB473KW01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 2.20e-10
R03 N02 N03 3.85e-03
C04 N03 N04 2.85e-06
R04 N03 N04 8.86e-01
C05 N04 N05 2.98e-06
R05 N04 N05 7.73e-02
C06 N05 N06 6.81e-07
R06 N05 N06 1.98e-02
L07 N06 N07 2.98e-10
R07 N06 N07 1.41e-01
C08 N07 N08 1.14e-07
L08 N07 N08 9.60e-11
R08 N07 N08 2.18e-01
C09 N08 N09 7.45e-08
L09 N08 N09 4.34e-11
R09 N08 N09 1.28e-01
C10 N09 Port2 7.17e-12
L10 N09 Port2 3.46e-10
R10 N09 Port2 4.28e+01
.ENDS GA355ER7GB473KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.50e-03[uF]/250[Vac]
* Murata P/N :GA342QR7GD152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD152KW01 Port1 Port2
C01 Port1 N01 1.60e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 3.00e-10
R03 N02 N03 1.85e-01
C04 N03 N04 2.40e-08
R04 N03 N04 2.10e+02
C05 N04 N05 1.81e-07
R05 N04 N05 4.64e+00
C06 N05 N06 9.33e-08
R06 N05 N06 1.23e+00
C07 N06 N07 7.50e-08
R07 N06 N07 2.11e-01
C08 N07 N08 2.39e-08
R08 N07 N08 1.32e-01
L09 N08 N09 1.53e-10
R09 N08 N09 8.64e-01
C10 N09 N10 6.64e-09
L10 N09 N10 5.23e-11
R10 N09 N10 3.15e-01
C11 N10 N11 2.76e-09
L11 N10 N11 2.55e-11
R11 N10 N11 2.30e-01
C12 N11 Port2 2.95e-12
L12 N11 Port2 5.29e-10
R12 N11 Port2 4.26e+01
.ENDS GA342QR7GD152KW01

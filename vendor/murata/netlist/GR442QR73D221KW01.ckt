*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/2.20e-04[uF]/2000[V]
* Murata P/N :GR442QR73D221KW01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 3[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D221KW01 Port1 Port2
C01 Port1 N01 2.21e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.43e-10
R03 N02 N03 6.32e-01
C04 N03 N04 7.61e-09
R04 N03 N04 7.25e+00
C05 N04 N05 2.10e-09
R05 N04 N05 7.63e-01
C06 N05 N06 6.97e-09
R06 N05 N06 7.15e-01
C07 N06 N07 2.20e-08
R07 N06 N07 1.89e-01
C08 N07 N08 1.01e-09
L08 N07 N08 6.20e-11
R08 N07 N08 9.06e-01
C09 N08 N09 5.59e-12
L09 N08 N09 3.57e-10
R09 N08 N09 3.43e+01
C10 N09 Port2 2.11e-12
L10 N09 Port2 3.33e-10
R10 N09 Port2 5.00e+01
.ENDS GR442QR73D221KW01

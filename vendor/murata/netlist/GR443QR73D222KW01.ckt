*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-03[uF]/2000[V]
* Murata P/N :GR443QR73D222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR443QR73D222KW01 Port1 Port2
C01 Port1 N01 2.22e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 2.77e-12
R03 N02 N03 1.38e-01
C04 N03 N04 4.36e-08
R04 N03 N04 7.28e+01
C05 N04 N05 1.61e-07
R05 N04 N05 1.10e+00
C06 N05 N06 8.75e-08
R06 N05 N06 2.30e-01
C07 N06 N07 5.27e-08
R07 N06 N07 7.62e-02
C08 N07 N08 4.78e-09
L08 N07 N08 8.24e-11
R08 N07 N08 4.81e-01
C09 N08 N09 1.23e-09
L09 N08 N09 3.78e-11
R09 N08 N09 3.80e-01
C10 N09 N10 7.65e-12
L10 N09 N10 2.40e-10
R10 N09 N10 2.28e+01
C11 N10 Port2 2.48e-12
L11 N10 Port2 3.44e-10
R11 N10 Port2 3.44e+01
.ENDS GR443QR73D222KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-03[uF]/250[Vac]
* Murata P/N :GA343QR7GD222KW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA343QR7GD222KW01 Port1 Port2
C01 Port1 N01 2.63e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 1.63e-10
R03 N02 N03 1.28e-01
C04 N03 N04 9.90e-09
R04 N03 N04 1.61e+03
C05 N04 N05 1.61e-07
R05 N04 N05 6.22e+00
C06 N05 N06 1.09e-07
R06 N05 N06 4.67e-01
C07 N06 N07 4.71e-07
R07 N06 N07 3.38e-01
C08 N07 N08 3.45e-08
R08 N07 N08 1.39e-01
L09 N08 N09 1.17e-10
R09 N08 N09 7.33e-01
C10 N09 N10 9.35e-09
L10 N09 N10 3.56e-11
R10 N09 N10 2.91e-01
C11 N10 N11 3.02e-09
L11 N10 N11 1.75e-11
R11 N10 N11 2.54e-01
C12 N11 Port2 4.01e-12
L12 N11 Port2 3.89e-10
R12 N11 Port2 3.13e+01
.ENDS GA343QR7GD222KW01

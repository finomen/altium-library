*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.50e-03[uF]/2000[V]
* Murata P/N :GR442QR73D152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D152KW01 Port1 Port2
C01 Port1 N01 1.61e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 7.90e-11
R03 N02 N03 1.87e-01
C04 N03 N04 3.53e-08
R04 N03 N04 5.67e+01
C05 N04 N05 1.14e-07
R05 N04 N05 1.16e+00
C06 N05 N06 5.56e-08
R06 N05 N06 3.11e-01
C07 N06 N07 2.33e-05
R07 N06 N07 2.89e-01
C08 N07 N08 3.79e-08
R08 N07 N08 6.80e-02
C09 N08 N09 6.42e-09
L09 N08 N09 6.16e-11
R09 N08 N09 4.26e-01
C10 N09 N10 9.29e-10
L10 N09 N10 6.28e-11
R10 N09 N10 3.64e-01
C11 N10 N11 6.12e-12
L11 N10 N11 2.95e-10
R11 N10 N11 2.36e+01
C12 N11 Port2 1.54e-12
L12 N11 Port2 5.81e-10
R12 N11 Port2 4.37e+01
.ENDS GR442QR73D152KW01

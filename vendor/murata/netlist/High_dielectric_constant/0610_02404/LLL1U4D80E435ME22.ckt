*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0610M(02404)/X6T(-55to105[deg])/4.30e+00[uF]/2.5[V]
* Murata P/N :LLL1U4D80E435ME22
* Property : C = 4.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL1U4D80E435ME22 Port1 Port2
C01 Port1 N01 3.81e-06
R01 Port1 N01 1.16e+07
L02 N01 N02 2.94e-11
R03 N02 N03 3.20e-03
C04 N03 N04 2.23e-04
R04 N03 N04 1.11e+01
C05 N04 N05 2.68e-04
R05 N04 N05 1.49e+00
C06 N05 N06 2.59e-04
R06 N05 N06 1.79e-01
C07 N06 N07 4.00e-04
R07 N06 N07 1.43e-02
C08 N07 N08 2.91e-04
R08 N07 N08 4.75e-03
L09 N08 N09 2.29e-11
R09 N08 N09 3.76e-02
L10 N09 N10 1.40e-10
R10 N09 N10 1.64e-02
C11 N10 N11 2.46e-05
L11 N10 N11 1.15e-11
R11 N10 N11 1.70e-03
C12 N11 N12 6.43e-06
L12 N11 N12 2.06e-11
R12 N11 N12 3.36e-03
C13 N12 N13 2.84e-11
L13 N12 N13 1.35e-11
R13 N12 N13 4.33e-01
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.81e-11
R14 N13 Port2 1.00e+01
.ENDS LLL1U4D80E435ME22

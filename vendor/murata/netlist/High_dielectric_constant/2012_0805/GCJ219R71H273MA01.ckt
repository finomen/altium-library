*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCJ219R71H273MA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H273MA01 Port1 Port2
C01 Port1 N01 2.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.25e-11
R03 N02 N03 4.62e-02
C04 N03 N04 3.31e-06
R04 N03 N04 1.20e+03
C05 N04 N05 1.01e-05
R05 N04 N05 8.91e+01
C06 N05 N06 4.34e-06
R06 N05 N06 2.95e+01
C07 N06 N07 4.28e-06
R07 N06 N07 2.95e+00
C08 N07 N08 3.56e-06
R08 N07 N08 4.33e-01
C09 N08 N09 2.67e-06
R09 N08 N09 7.26e-02
C10 N09 N10 3.10e-06
R10 N09 N10 1.52e-02
L11 N10 N11 7.06e-11
R11 N10 N11 1.06e-01
C12 N11 N12 2.04e-07
L12 N11 N12 1.06e-11
R12 N11 N12 2.30e-02
C13 N12 N13 2.34e-08
L13 N12 N13 3.35e-11
R13 N12 N13 6.27e-02
C14 N13 N14 4.63e-11
L14 N13 N14 1.75e-10
R14 N13 N14 2.38e+00
C15 N14 Port2 9.99e-13
L15 N14 Port2 2.04e-10
R15 N14 Port2 2.89e+01
.ENDS GCJ219R71H273MA01

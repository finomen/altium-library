*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GCJ21BR71E225KA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71E225KA01 Port1 Port2
C01 Port1 N01 1.55e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.63e-10
R03 N02 N03 7.15e-03
C04 N03 N04 6.83e-05
R04 N03 N04 2.35e+01
C05 N04 N05 6.18e-05
R05 N04 N05 3.16e+00
C06 N05 N06 5.42e-05
R06 N05 N06 4.19e-01
C07 N06 N07 4.53e-05
R07 N06 N07 5.84e-02
C08 N07 N08 2.89e-05
R08 N07 N08 1.14e-02
L09 N08 N09 1.77e-11
R09 N08 N09 7.50e-02
L10 N09 N10 2.11e-10
R10 N09 N10 3.10e-02
L11 N10 N11 2.10e-11
R11 N10 N11 2.15e-02
C12 N11 N12 4.20e-06
L12 N11 N12 6.25e-11
R12 N11 N12 1.24e-02
C13 N12 N13 2.20e-06
L13 N12 N13 5.21e-11
R13 N12 N13 1.20e-02
C14 N13 N14 2.05e-11
L14 N13 N14 4.83e-11
R14 N13 N14 7.03e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.31e-10
R15 N14 Port2 2.69e+01
.ENDS GCJ21BR71E225KA01

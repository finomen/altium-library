*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE216R72A152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A152KA01 Port1 Port2
C01 Port1 N01 1.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.18e-11
R03 N02 N03 2.63e-01
C04 N03 N04 1.46e-07
R04 N03 N04 1.18e+04
C05 N04 N05 2.73e-07
R05 N04 N05 4.91e+02
C06 N05 N06 2.25e-07
R06 N05 N06 7.10e+01
C07 N06 N07 1.65e-07
R07 N06 N07 9.31e+00
C08 N07 N08 1.11e-07
R08 N07 N08 1.32e+00
C09 N08 N09 3.12e-08
R09 N08 N09 3.61e-01
C10 N09 N10 7.31e-09
L10 N09 N10 9.27e-12
R10 N09 N10 6.65e-02
C11 N10 N11 7.49e-10
L11 N10 N11 4.29e-11
R11 N10 N11 3.20e-01
C12 N11 N12 4.21e-11
L12 N11 N12 8.52e-11
R12 N11 N12 1.97e+00
C13 N12 N13 4.72e-12
L13 N12 N13 1.50e-10
R13 N12 N13 1.46e+01
C14 N13 Port2 2.14e-12
L14 N13 Port2 1.80e-10
R14 N13 Port2 1.91e+01
.ENDS GCE216R72A152KA01

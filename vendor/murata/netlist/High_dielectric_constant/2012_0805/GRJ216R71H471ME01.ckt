*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/50[V]
* Murata P/N :GRJ216R71H471ME01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R71H471ME01 Port1 Port2
C01 Port1 N01 4.79e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 7.60e-11
R03 N02 N03 3.32e-01
C04 N03 N04 3.27e-08
R04 N03 N04 7.37e+04
C05 N04 N05 8.74e-08
R05 N04 N05 2.50e+03
C06 N05 N06 7.09e-08
R06 N05 N06 3.14e+02
C07 N06 N07 5.62e-08
R07 N06 N07 3.92e+01
C08 N07 N08 3.38e-08
R08 N07 N08 5.96e+00
C09 N08 N09 1.20e-08
R09 N08 N09 1.16e+00
C10 N09 N10 3.27e-09
R10 N09 N10 3.70e-01
L11 N10 N11 1.37e-10
R11 N10 N11 5.12e+00
C12 N11 N12 1.56e-09
L12 N11 N12 1.19e-11
R12 N11 N12 1.75e-01
C13 N12 N13 6.67e-10
L13 N12 N13 1.08e-11
R13 N12 N13 2.42e-01
C14 N13 N14 5.13e-12
L14 N13 N14 1.46e-10
R14 N13 N14 1.32e+01
C15 N14 Port2 4.14e-12
L15 N14 Port2 6.59e-11
R15 N14 Port2 2.14e+01
.ENDS GRJ216R71H471ME01

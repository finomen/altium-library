*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/1.00e-02[uF]/450[V]
* Murata P/N :GR321AD7LP103KW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR321AD7LP103KW01 Port1 Port2
C01 Port1 N01 9.84e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.15e-10
R03 N02 N03 2.78e-02
C04 N03 N04 2.46e-06
R04 N03 N04 1.59e+03
C05 N04 N05 3.97e-06
R05 N04 N05 1.33e+02
C06 N05 N06 4.01e-06
R06 N05 N06 2.73e+01
C07 N06 N07 3.80e-06
R07 N06 N07 6.12e+00
C08 N07 N08 3.22e-06
R08 N07 N08 1.39e+00
C09 N08 N09 2.74e-06
R09 N08 N09 2.85e-01
C10 N09 N10 2.17e-06
R10 N09 N10 7.07e-02
L11 N10 N11 1.08e-11
R11 N10 N11 1.08e-01
L12 N11 N12 1.10e-11
R12 N11 N12 9.57e-02
C13 N12 N13 6.89e-08
L13 N12 N13 1.39e-11
R13 N12 N13 6.13e-02
C14 N13 N14 1.46e-08
L14 N13 N14 2.37e-11
R14 N13 N14 1.22e-01
C15 N14 N15 5.12e-11
L15 N14 N15 4.08e-11
R15 N14 N15 1.65e+00
C16 N15 Port2 1.95e-11
L16 N15 Port2 7.55e-11
R16 N15 Port2 1.71e-01
.ENDS GR321AD7LP103KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/50[V]
* Murata P/N :GCJ216R71H331MA01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H331MA01 Port1 Port2
C01 Port1 N01 3.37e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.03e-11
R03 N02 N03 1.33e+00
C04 N03 N04 2.35e-08
R04 N03 N04 6.00e+04
C05 N04 N05 5.96e-08
R05 N04 N05 2.03e+03
C06 N05 N06 4.41e-08
R06 N05 N06 2.23e+02
C07 N06 N07 3.15e-08
R07 N06 N07 2.62e+01
C08 N07 N08 1.08e-08
R08 N07 N08 5.53e+00
C09 N08 N09 6.16e-09
R09 N08 N09 6.58e-01
C10 N09 N10 2.77e-09
R10 N09 N10 4.10e-01
C11 N10 N11 4.86e-10
L11 N10 N11 1.19e-11
R11 N10 N11 3.63e-01
C12 N11 N12 7.93e-12
L12 N11 N12 1.09e-10
R12 N11 N12 8.58e+00
C13 N12 N13 8.53e-12
L13 N12 N13 6.22e-11
R13 N12 N13 9.65e+00
C14 N13 Port2 1.33e-12
L14 N13 Port2 1.96e-10
R14 N13 Port2 2.70e+01
.ENDS GCJ216R71H331MA01

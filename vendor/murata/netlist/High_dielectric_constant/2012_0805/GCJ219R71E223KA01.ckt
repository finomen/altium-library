*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :GCJ219R71E223KA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E223KA01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 7.37e-02
C04 N03 N04 2.69e-06
R04 N03 N04 1.48e+03
C05 N04 N05 4.53e-06
R05 N04 N05 1.58e+02
C06 N05 N06 3.72e-06
R06 N05 N06 2.40e+01
C07 N06 N07 3.00e-06
R07 N06 N07 3.16e+00
C08 N07 N08 2.99e-06
R08 N07 N08 5.84e-01
C09 N08 N09 1.43e-06
R09 N08 N09 1.37e-01
C10 N09 N10 2.05e-06
R10 N09 N10 2.36e-02
L11 N10 N11 1.04e-10
R11 N10 N11 1.52e-01
C12 N11 N12 1.30e-07
L12 N11 N12 1.63e-11
R12 N11 N12 3.07e-02
C13 N12 N13 2.69e-08
L13 N12 N13 3.05e-11
R13 N12 N13 7.87e-02
C14 N13 N14 7.14e-12
L14 N13 N14 1.49e-10
R14 N13 N14 1.80e+01
C15 N14 Port2 2.43e-12
L15 N14 Port2 1.59e-10
R15 N14 Port2 2.25e+01
.ENDS GCJ219R71E223KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H224KE01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H224KE01 Port1 Port2
C01 Port1 N01 2.11e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.28e-10
R03 N02 N03 2.28e-02
C04 N03 N04 1.45e-05
R04 N03 N04 1.91e-01
C05 N04 N05 2.24e-05
R05 N04 N05 2.16e-02
C06 N05 N06 2.43e-05
R06 N05 N06 3.69e-03
L07 N06 N07 1.77e-10
R07 N06 N07 6.47e-02
L08 N07 N08 1.12e-11
R08 N07 N08 3.05e-02
C09 N08 N09 7.77e-07
L09 N08 N09 3.77e-11
R09 N08 N09 2.83e-02
C10 N09 N10 4.02e-07
L10 N09 N10 3.15e-11
R10 N09 N10 2.83e-02
C11 N10 N11 2.01e-11
L11 N10 N11 5.61e-11
R11 N10 N11 4.74e+00
C12 N11 Port2 3.41e-12
L12 N11 Port2 9.32e-11
R12 N11 Port2 1.14e+01
.ENDS GRJ21BR71H224KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :ZRA21CR61E226ME01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRA21CR61E226ME01 Port1 Port2
C01 Port1 N01 1.66e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.61e-10
R03 N02 N03 2.38e-03
C04 N03 N04 6.39e-04
R04 N03 N04 7.71e+00
C05 N04 N05 8.31e-04
R05 N04 N05 7.00e-01
C06 N05 N06 7.65e-04
R06 N05 N06 9.79e-02
C07 N06 N07 7.62e-04
R07 N06 N07 1.37e-02
C08 N07 N08 6.53e-04
R08 N07 N08 3.06e-03
L09 N08 N09 1.85e-11
R09 N08 N09 7.39e-02
L10 N09 N10 4.48e-11
R10 N09 N10 2.27e-02
L11 N10 N11 3.62e-10
R11 N10 N11 1.29e-02
C12 N11 N12 4.47e-05
L12 N11 N12 8.24e-11
R12 N11 N12 3.94e-03
C13 N12 N13 3.06e-05
L13 N12 N13 5.89e-11
R13 N12 N13 3.81e-03
C14 N13 Port2 2.75e-12
L14 N13 Port2 1.40e-10
R14 N13 Port2 4.67e+01
.ENDS ZRA21CR61E226ME01

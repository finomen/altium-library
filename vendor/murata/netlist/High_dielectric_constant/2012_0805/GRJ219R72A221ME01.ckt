*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-04[uF]/100[V]
* Murata P/N :GRJ219R72A221ME01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ219R72A221ME01 Port1 Port2
C01 Port1 N01 2.36e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 1.64e-11
R03 N02 N03 4.99e-01
C04 N03 N04 1.36e-08
R04 N03 N04 1.24e+05
C05 N04 N05 4.06e-08
R05 N04 N05 3.20e+03
C06 N05 N06 3.47e-08
R06 N05 N06 2.98e+02
C07 N06 N07 2.54e-08
R07 N06 N07 4.10e+01
C08 N07 N08 1.44e-08
R08 N07 N08 6.31e+00
C09 N08 N09 8.22e-09
R09 N08 N09 1.16e+00
C10 N09 N10 4.09e-09
R10 N09 N10 6.51e-01
C11 N10 N11 1.52e-09
R11 N10 N11 4.79e-01
C12 N11 N12 5.00e-12
L12 N11 N12 2.72e-10
R12 N11 N12 1.70e+01
C13 N12 Port2 4.88e-13
L13 N12 Port2 3.06e-10
R13 N12 Port2 2.18e+01
.ENDS GRJ219R72A221ME01

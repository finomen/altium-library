*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCD216R71H472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H472KA01 Port1 Port2
C01 Port1 N01 4.88e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 7.98e-02
C04 N03 N04 6.87e-07
R04 N03 N04 2.97e+03
C05 N04 N05 8.39e-07
R05 N04 N05 2.31e+02
C06 N05 N06 1.01e-06
R06 N05 N06 2.36e+01
C07 N06 N07 8.50e-07
R07 N06 N07 5.92e+00
C08 N07 N08 6.50e-07
R08 N07 N08 1.37e+00
C09 N08 N09 4.94e-07
R09 N08 N09 2.85e-01
C10 N09 N10 3.55e-07
R10 N09 N10 9.82e-02
C11 N10 N11 1.39e-07
R11 N10 N11 3.99e-02
C12 N11 N12 1.85e-08
L12 N11 N12 1.49e-11
R12 N11 N12 7.01e-02
C13 N12 N13 2.92e-09
L13 N12 N13 3.29e-11
R13 N12 N13 1.90e-01
C14 N13 N14 4.26e-11
L14 N13 N14 1.21e-10
R14 N13 N14 1.28e+00
C15 N14 N15 4.27e-12
L15 N14 N15 1.13e-10
R15 N14 N15 1.70e+01
C16 N15 Port2 4.19e-12
L16 N15 Port2 7.85e-11
R16 N15 Port2 1.45e+01
.ENDS GCD216R71H472KA01

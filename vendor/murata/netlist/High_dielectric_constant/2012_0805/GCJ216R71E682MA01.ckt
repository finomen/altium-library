*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/25[V]
* Murata P/N :GCJ216R71E682MA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E682MA01 Port1 Port2
C01 Port1 N01 6.86e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.12e-10
R03 N02 N03 1.15e-01
C04 N03 N04 8.79e-07
R04 N03 N04 2.85e+03
C05 N04 N05 1.18e-06
R05 N04 N05 1.93e+02
C06 N05 N06 1.10e-06
R06 N05 N06 2.16e+01
C07 N06 N07 8.85e-07
R07 N06 N07 2.85e+00
C08 N07 N08 6.95e-07
R08 N07 N08 4.50e-01
C09 N08 N09 3.44e-07
R09 N08 N09 1.21e-01
C10 N09 N10 2.61e-09
L10 N09 N10 5.29e-11
R10 N09 N10 1.61e-01
C11 N10 N11 2.77e-11
L11 N10 N11 2.43e-10
R11 N10 N11 3.16e+00
C12 N11 N12 1.17e-10
L12 N11 N12 7.56e-12
R12 N11 N12 1.39e+00
C13 N12 N13 4.77e-12
L13 N12 N13 1.14e-10
R13 N12 N13 1.39e+01
C14 N13 Port2 2.16e-12
L14 N13 Port2 1.43e-10
R14 N13 Port2 2.28e+01
.ENDS GCJ216R71E682MA01

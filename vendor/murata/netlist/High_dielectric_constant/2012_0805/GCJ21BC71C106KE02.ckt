*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ21BC71C106KE02
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BC71C106KE02 Port1 Port2
C01 Port1 N01 7.68e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.44e-10
R03 N02 N03 4.35e-03
C04 N03 N04 2.98e-04
R04 N03 N04 1.26e+01
C05 N04 N05 3.68e-04
R05 N04 N05 1.10e+00
C06 N05 N06 4.56e-04
R06 N05 N06 1.26e-01
C07 N06 N07 3.63e-04
R07 N06 N07 3.05e-02
C08 N07 N08 2.27e-04
R08 N07 N08 5.86e-03
L09 N08 N09 1.22e-11
R09 N08 N09 6.25e-02
L10 N09 N10 4.49e-11
R10 N09 N10 3.29e-02
L11 N10 N11 3.23e-10
R11 N10 N11 1.93e-02
C12 N11 N12 1.99e-05
L12 N11 N12 8.37e-11
R12 N11 N12 5.80e-03
C13 N12 N13 9.18e-06
L13 N12 N13 8.15e-11
R13 N12 N13 6.12e-03
C14 N13 N14 1.25e-11
L14 N13 N14 5.11e-11
R14 N13 N14 6.76e+00
C15 N14 Port2 4.04e-12
L15 N14 Port2 6.89e-11
R15 N14 Port2 2.82e+01
.ENDS GCJ21BC71C106KE02

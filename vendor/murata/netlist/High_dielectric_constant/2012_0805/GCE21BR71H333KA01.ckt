*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCE21BR71H333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H333KA01 Port1 Port2
C01 Port1 N01 3.42e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.28e-11
R03 N02 N03 3.36e-02
C04 N03 N04 4.06e-06
R04 N03 N04 7.28e+02
C05 N04 N05 6.92e-06
R05 N04 N05 7.99e+01
C06 N05 N06 5.78e-06
R06 N05 N06 1.59e+01
C07 N06 N07 6.43e-06
R07 N06 N07 2.97e+00
C08 N07 N08 3.42e-06
R08 N07 N08 8.32e-01
C09 N08 N09 2.08e-06
R09 N08 N09 1.38e-01
C10 N09 N10 2.27e-06
R10 N09 N10 2.27e-02
L11 N10 N11 1.08e-10
R11 N10 N11 1.20e-01
C12 N11 N12 2.16e-07
L12 N11 N12 1.88e-11
R12 N11 N12 4.85e-02
C13 N12 N13 3.57e-08
L13 N12 N13 4.41e-11
R13 N12 N13 7.81e-02
C14 N13 N14 1.07e-11
L14 N13 N14 1.20e-10
R14 N13 N14 1.40e+01
C15 N14 N15 1.05e-11
L15 N14 N15 6.38e-11
R15 N14 N15 9.83e+00
C16 N15 Port2 2.19e-12
L16 N15 Port2 1.94e-10
R16 N15 Port2 2.57e+01
.ENDS GCE21BR71H333KA01

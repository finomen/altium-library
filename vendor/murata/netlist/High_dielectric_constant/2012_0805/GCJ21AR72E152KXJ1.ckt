*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E152KXJ1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E152KXJ1 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.90e-10
R03 N02 N03 2.89e-01
C04 N03 N04 2.16e-07
R04 N03 N04 8.16e+03
C05 N04 N05 2.08e-07
R05 N04 N05 2.25e+03
C06 N05 N06 1.84e-07
R06 N05 N06 4.68e+02
C07 N06 N07 1.78e-07
R07 N06 N07 9.58e+01
C08 N07 N08 1.50e-07
R08 N07 N08 2.11e+01
C09 N08 N09 1.23e-07
R09 N08 N09 4.40e+00
C10 N09 N10 7.58e-08
R10 N09 N10 1.25e+00
C11 N10 N11 3.33e-08
R11 N10 N11 3.33e-01
L12 N11 N12 1.09e-10
R12 N11 N12 2.55e+00
L13 N12 N13 4.18e-11
R13 N12 N13 9.89e-01
C14 N13 N14 5.98e-10
L14 N13 N14 1.75e-11
R14 N13 N14 4.69e-01
C15 N14 Port2 4.81e-11
L15 N14 Port2 1.12e-10
R15 N14 Port2 2.19e+00
.ENDS GCJ21AR72E152KXJ1

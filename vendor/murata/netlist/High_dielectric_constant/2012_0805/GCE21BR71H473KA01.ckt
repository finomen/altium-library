*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCE21BR71H473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H473KA01 Port1 Port2
C01 Port1 N01 4.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.57e-11
R03 N02 N03 3.82e-02
C04 N03 N04 5.86e-06
R04 N03 N04 6.76e+02
C05 N04 N05 9.99e-06
R05 N04 N05 6.16e+01
C06 N05 N06 7.97e-06
R06 N05 N06 1.48e+01
C07 N06 N07 7.89e-06
R07 N06 N07 3.09e+00
C08 N07 N08 5.06e-06
R08 N07 N08 5.88e-01
C09 N08 N09 3.48e-06
R09 N08 N09 1.13e-01
C10 N09 N10 2.81e-06
R10 N09 N10 1.40e-02
L11 N10 N11 7.26e-11
R11 N10 N11 1.25e-01
C12 N11 N12 1.48e-07
L12 N11 N12 4.35e-11
R12 N11 N12 6.81e-02
C13 N12 N13 7.58e-08
L13 N12 N13 3.63e-11
R13 N12 N13 6.84e-02
C14 N13 N14 9.43e-09
L14 N13 N14 8.78e-11
R14 N13 N14 6.69e-02
C15 N14 N15 1.06e-11
L15 N14 N15 9.70e-11
R15 N14 N15 1.15e+01
C16 N15 Port2 1.77e-12
L16 N15 Port2 1.99e-10
R16 N15 Port2 3.58e+01
.ENDS GCE21BR71H473KA01

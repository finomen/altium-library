*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E224MA01 Port1 Port2
C01 Port1 N01 2.18e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.02e-10
R03 N02 N03 8.10e-02
C04 N03 N04 2.13e-05
R04 N03 N04 1.87e+02
C05 N04 N05 3.56e-05
R05 N04 N05 1.63e+01
C06 N05 N06 3.88e-05
R06 N05 N06 1.87e+00
C07 N06 N07 3.75e-05
R07 N06 N07 5.91e-01
C08 N07 N08 1.59e-05
R08 N07 N08 1.87e-01
C09 N08 N09 2.07e-05
R09 N08 N09 1.79e-02
L10 N09 N10 1.65e-10
R10 N09 N10 8.39e-02
C11 N10 N11 6.71e-07
L11 N10 N11 4.80e-11
R11 N10 N11 2.92e-02
C12 N11 N12 3.37e-07
L12 N11 N12 4.00e-11
R12 N11 N12 3.42e-02
C13 N12 N13 1.48e-11
L13 N12 N13 8.04e-11
R13 N12 N13 8.15e+00
C14 N13 Port2 1.59e-12
L14 N13 Port2 1.88e-10
R14 N13 Port2 2.88e+01
.ENDS GCJ21BL81E224MA01

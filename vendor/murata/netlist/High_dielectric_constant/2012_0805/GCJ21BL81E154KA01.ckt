*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ21BL81E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81E154KA01 Port1 Port2
C01 Port1 N01 1.49e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.17e-10
R03 N02 N03 3.09e-02
C04 N03 N04 1.62e-05
R04 N03 N04 2.45e+02
C05 N04 N05 2.63e-05
R05 N04 N05 2.04e+01
C06 N05 N06 2.35e-05
R06 N05 N06 4.17e+00
C07 N06 N07 1.71e-05
R07 N06 N07 6.91e-01
C08 N07 N08 1.28e-05
R08 N07 N08 8.69e-02
C09 N08 N09 9.71e-06
R09 N08 N09 1.76e-02
L10 N09 N10 1.62e-10
R10 N09 N10 7.07e-02
L11 N10 N11 1.02e-11
R11 N10 N11 4.14e-02
C12 N11 N12 5.98e-07
L12 N11 N12 3.41e-11
R12 N11 N12 2.60e-02
C13 N12 N13 2.78e-07
L13 N12 N13 2.96e-11
R13 N12 N13 2.95e-02
C14 N13 N14 1.92e-11
L14 N13 N14 6.46e-11
R14 N13 N14 7.62e+00
C15 N14 Port2 1.29e-12
L15 N14 Port2 2.19e-10
R15 N14 Port2 2.68e+01
.ENDS GCJ21BL81E154KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCH21BR71E105KE01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BR71E105KE01 Port1 Port2
C01 Port1 N01 9.92e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.97e-12
R03 N02 N03 4.95e-03
C04 N03 N04 1.48e-04
R04 N03 N04 2.79e+01
C05 N04 N05 2.13e-04
R05 N04 N05 2.67e+00
C06 N05 N06 1.35e-04
R06 N05 N06 6.52e-01
C07 N06 N07 1.21e-04
R07 N06 N07 9.61e-02
C08 N07 N08 1.30e-04
R08 N07 N08 1.49e-02
C09 N08 N09 1.11e-04
R09 N08 N09 4.00e-03
L10 N09 N10 1.42e-11
R10 N09 N10 4.86e-02
L11 N10 N11 2.01e-10
R11 N10 N11 3.97e-02
C12 N11 N12 2.98e-06
L12 N11 N12 5.78e-11
R12 N11 N12 1.67e-02
C13 N12 N13 1.50e-06
L13 N12 N13 5.35e-11
R13 N12 N13 1.76e-02
C14 N13 N14 2.97e-11
L14 N13 N14 3.44e-11
R14 N13 N14 6.28e+00
C15 N14 N15 4.18e-12
L15 N14 N15 7.31e-11
R15 N14 N15 1.00e+05
C16 N15 Port2 1.38e-12
L16 N15 Port2 2.19e-10
R16 N15 Port2 2.24e+01
.ENDS GCH21BR71E105KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCJ216R72A103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A103MA01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-11
R03 N02 N03 3.79e-01
C04 N03 N04 1.73e-06
R04 N03 N04 1.52e+03
C05 N04 N05 2.22e-06
R05 N04 N05 2.53e+02
C06 N05 N06 2.63e-06
R06 N05 N06 3.11e+01
C07 N06 N07 2.08e-06
R07 N06 N07 1.21e+01
C08 N07 N08 1.03e-06
R08 N07 N08 3.65e+00
C09 N08 N09 5.60e-07
R09 N08 N09 5.96e-01
C10 N09 N10 6.92e-07
R10 N09 N10 9.05e-02
L11 N10 N11 5.99e-11
R11 N10 N11 2.35e-01
C12 N11 N12 5.31e-09
L12 N11 N12 5.39e-11
R12 N11 N12 1.32e-01
C13 N12 N13 5.90e-11
L13 N12 N13 1.19e-10
R13 N12 N13 1.70e+00
C14 N13 N14 4.91e-12
L14 N13 N14 1.20e-10
R14 N13 N14 1.38e+01
C15 N14 Port2 9.23e-13
L15 N14 Port2 2.44e-10
R15 N14 Port2 2.52e+01
.ENDS GCJ216R72A103MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GGD21BR72A473KA02
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGD21BR72A473KA02 Port1 Port2
C01 Port1 N01 4.62e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-11
R03 N02 N03 1.45e-02
C04 N03 N04 5.46e-06
R04 N03 N04 6.76e+02
C05 N04 N05 1.13e-05
R05 N04 N05 5.13e+01
C06 N05 N06 7.56e-06
R06 N05 N06 1.66e+01
C07 N06 N07 6.19e-06
R07 N06 N07 2.46e+00
C08 N07 N08 4.08e-06
R08 N07 N08 3.56e-01
C09 N08 N09 2.74e-06
R09 N08 N09 5.25e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.24e-01
C11 N10 N11 1.51e-07
L11 N10 N11 4.21e-11
R11 N10 N11 1.01e-01
C12 N11 N12 6.75e-08
L12 N11 N12 4.19e-11
R12 N11 N12 8.58e-02
C13 N12 N13 4.78e-08
L13 N12 N13 2.13e-11
R13 N12 N13 3.74e-02
C14 N13 N14 1.64e-11
L14 N13 N14 4.82e-11
R14 N13 N14 9.19e+00
C15 N14 Port2 9.03e-13
L15 N14 Port2 2.63e-10
R15 N14 Port2 2.96e+01
.ENDS GGD21BR72A473KA02

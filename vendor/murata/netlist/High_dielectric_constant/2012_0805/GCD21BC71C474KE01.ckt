*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GCD21BC71C474KE01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BC71C474KE01 Port1 Port2
C01 Port1 N01 4.50e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.56e-10
R03 N02 N03 5.28e-03
C04 N03 N04 5.20e-05
R04 N03 N04 7.65e+01
C05 N04 N05 6.33e-05
R05 N04 N05 9.85e+00
C06 N05 N06 5.40e-05
R06 N05 N06 1.56e+00
C07 N06 N07 6.72e-05
R07 N06 N07 1.97e-01
C08 N07 N08 4.24e-05
R08 N07 N08 5.76e-02
C09 N08 N09 3.31e-05
R09 N08 N09 8.03e-03
L10 N09 N10 2.26e-10
R10 N09 N10 6.21e-02
L11 N10 N11 1.38e-11
R11 N10 N11 5.36e-02
C12 N11 N12 1.36e-06
L12 N11 N12 6.09e-11
R12 N11 N12 4.11e-02
C13 N12 N13 7.65e-07
L13 N12 N13 5.38e-11
R13 N12 N13 3.57e-02
C14 N13 N14 8.09e-12
L14 N13 N14 6.91e-11
R14 N13 N14 9.50e+00
C15 N14 Port2 6.36e-12
L15 N14 Port2 5.29e-11
R15 N14 Port2 1.88e+01
.ENDS GCD21BC71C474KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :LLL216R71E473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71E473MA01 Port1 Port2
C01 Port1 N01 4.67e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.68e-11
R03 N02 N03 1.49e-02
C04 N03 N04 5.53e-06
R04 N03 N04 6.20e+02
C05 N04 N05 8.52e-06
R05 N04 N05 7.28e+01
C06 N05 N06 1.06e-05
R06 N05 N06 1.24e+01
C07 N06 N07 6.87e-06
R07 N06 N07 4.00e+00
C08 N07 N08 5.50e-06
R08 N07 N08 5.52e-01
C09 N08 N09 4.43e-06
R09 N08 N09 7.78e-02
C10 N09 N10 3.16e-06
R10 N09 N10 1.82e-02
L11 N10 N11 3.63e-11
R11 N10 N11 9.25e-02
C12 N11 N12 6.90e-08
L12 N11 N12 1.89e-11
R12 N11 N12 2.89e-02
C13 N12 N13 4.62e-08
L13 N12 N13 7.75e-12
R13 N12 N13 2.07e-02
C14 N13 Port2 5.10e-12
L14 N13 Port2 9.94e-11
R14 N13 Port2 1.46e+01
.ENDS LLL216R71E473MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :KRM21ER61E106KFA1
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM21ER61E106KFA1 Port1 Port2
C01 Port1 N01 7.07e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.10e-10
R03 N02 N03 5.44e-03
C04 N03 N04 1.58e-04
R04 N03 N04 5.04e+00
C05 N04 N05 1.68e-04
R05 N04 N05 2.98e-01
C06 N05 N06 1.61e-04
R06 N05 N06 2.04e-02
L07 N06 N07 1.86e-11
R07 N06 N07 4.91e-01
L08 N07 N08 1.01e-10
R08 N07 N08 8.95e-02
L09 N08 N09 6.28e-10
R09 N08 N09 3.15e-02
L10 N09 N10 3.04e-10
R10 N09 N10 5.48e-03
C11 N10 Port2 1.33e-12
L11 N10 Port2 2.85e-10
R11 N10 Port2 1.43e+02
.ENDS KRM21ER61E106KFA1

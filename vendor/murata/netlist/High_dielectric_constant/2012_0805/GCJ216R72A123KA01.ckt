*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCJ216R72A123KA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A123KA01 Port1 Port2
C01 Port1 N01 1.22e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 6.35e-02
C04 N03 N04 1.51e-06
R04 N03 N04 2.39e+03
C05 N04 N05 2.46e-06
R05 N04 N05 1.47e+02
C06 N05 N06 2.17e-06
R06 N05 N06 2.62e+01
C07 N06 N07 1.71e-06
R07 N06 N07 3.79e+00
C08 N07 N08 1.42e-06
R08 N07 N08 5.51e-01
C09 N08 N09 6.57e-07
R09 N08 N09 1.20e-01
L10 N09 N10 8.75e-11
R10 N09 N10 3.57e-01
C11 N10 N11 7.55e-08
L11 N10 N11 1.68e-11
R11 N10 N11 2.61e-02
C12 N11 N12 9.41e-09
L12 N11 N12 4.42e-11
R12 N11 N12 1.14e-01
C13 N12 N13 6.63e-11
L13 N12 N13 9.53e-11
R13 N12 N13 1.15e+00
C14 N13 N14 5.55e-12
L14 N13 N14 1.26e-10
R14 N13 N14 1.34e+01
C15 N14 Port2 4.02e-12
L15 N14 Port2 8.41e-11
R15 N14 Port2 1.81e+01
.ENDS GCJ216R72A123KA01

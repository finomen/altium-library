*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C105MA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C105MA01 Port1 Port2
C01 Port1 N01 9.44e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 2.04e-10
R03 N02 N03 7.11e-03
C04 N03 N04 4.80e-04
R04 N03 N04 2.13e+00
C05 N04 N05 1.52e-04
R05 N04 N05 1.47e+00
C06 N05 N06 1.22e-04
R06 N05 N06 2.70e-01
C07 N06 N07 1.09e-04
R07 N06 N07 4.06e-02
C08 N07 N08 7.81e-05
R08 N07 N08 8.74e-03
L09 N08 N09 1.24e-11
R09 N08 N09 7.06e-02
L10 N09 N10 2.29e-10
R10 N09 N10 3.87e-02
L11 N10 N11 1.91e-11
R11 N10 N11 2.85e-02
C12 N11 N12 3.08e-06
L12 N11 N12 5.71e-11
R12 N11 N12 1.43e-02
C13 N12 N13 1.56e-06
L13 N12 N13 4.94e-11
R13 N12 N13 1.54e-02
C14 N13 N14 1.39e-11
L14 N13 N14 7.92e-11
R14 N13 N14 8.97e+00
C15 N14 Port2 6.47e-12
L15 N14 Port2 5.67e-11
R15 N14 Port2 1.86e+01
.ENDS GCJ21BR71C105MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/100[V]
* Murata P/N :GCJ219R72A821KA01
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A821KA01 Port1 Port2
C01 Port1 N01 8.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 9.29e-11
R03 N02 N03 2.79e-01
C04 N03 N04 1.14e-07
R04 N03 N04 3.86e+04
C05 N04 N05 1.53e-07
R05 N04 N05 5.32e+03
C06 N05 N06 2.14e-07
R06 N05 N06 6.40e+02
C07 N06 N07 1.35e-07
R07 N06 N07 2.38e+02
C08 N07 N08 9.48e-08
R08 N07 N08 3.36e+01
C09 N08 N09 5.72e-08
R09 N08 N09 5.17e+00
C10 N09 N10 2.82e-08
R10 N09 N10 8.23e-01
C11 N10 N11 7.59e-09
R11 N10 N11 2.87e-01
C12 N11 N12 1.10e-08
L12 N11 N12 5.59e-12
R12 N11 N12 1.04e-01
C13 N12 N13 4.35e-10
L13 N12 N13 4.80e-11
R13 N12 N13 3.96e-01
C14 N13 N14 4.96e-12
L14 N13 N14 1.92e-10
R14 N13 N14 1.40e+01
C15 N14 Port2 1.68e-12
L15 N14 Port2 1.88e-10
R15 N14 Port2 2.05e+01
.ENDS GCJ219R72A821KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :KRM21FR61E226MFA1
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM21FR61E226MFA1 Port1 Port2
C01 Port1 N01 1.56e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.97e-10
R03 N02 N03 4.17e-03
C04 N03 N04 5.80e-04
R04 N03 N04 1.73e+00
C05 N04 N05 6.68e-04
R05 N04 N05 1.34e-01
C06 N05 N06 6.77e-04
R06 N05 N06 1.42e-02
C07 N06 N07 1.43e-03
R07 N06 N07 1.14e-03
L08 N07 N08 1.02e-10
R08 N07 N08 5.25e-02
L09 N08 N09 4.89e-10
R09 N08 N09 3.26e-02
L10 N09 N10 5.37e-10
R10 N09 N10 7.64e-03
C11 N10 N11 1.82e-05
L11 N10 N11 1.18e-10
R11 N10 N11 3.93e-03
C12 N11 N12 7.79e-10
L12 N11 N12 1.35e-11
R12 N11 N12 6.47e-02
C13 N12 N13 5.14e-12
L13 N12 N13 1.05e-10
R13 N12 N13 1.10e+02
C14 N13 Port2 1.13e-12
L14 N13 Port2 3.57e-10
R14 N13 Port2 2.25e+02
.ENDS KRM21FR61E226MFA1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/100[V]
* Murata P/N :GCJ219R72A561KA01
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A561KA01 Port1 Port2
C01 Port1 N01 5.84e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 6.95e-11
R03 N02 N03 3.92e-01
C04 N03 N04 7.11e-08
R04 N03 N04 2.99e+04
C05 N04 N05 1.25e-07
R05 N04 N05 2.43e+03
C06 N05 N06 8.01e-08
R06 N05 N06 3.59e+02
C07 N06 N07 6.30e-08
R07 N06 N07 4.32e+01
C08 N07 N08 4.85e-08
R08 N07 N08 4.63e+00
C09 N08 N09 1.64e-08
R09 N08 N09 1.53e+00
C10 N09 N10 4.47e-09
R10 N09 N10 3.92e-01
C11 N10 N11 2.12e-09
L11 N10 N11 1.61e-11
R11 N10 N11 1.38e-01
C12 N11 N12 8.32e-10
L12 N11 N12 1.04e-11
R12 N11 N12 2.17e-01
C13 N12 N13 3.33e-12
L13 N12 N13 2.79e-10
R13 N12 N13 1.86e+01
C14 N13 Port2 3.52e-12
L14 N13 Port2 1.36e-10
R14 N13 Port2 1.82e+01
.ENDS GCJ219R72A561KA01

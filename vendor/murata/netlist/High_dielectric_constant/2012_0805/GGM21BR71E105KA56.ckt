*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GGM21BR71E105KA56
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM21BR71E105KA56 Port1 Port2
C01 Port1 N01 9.92e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.45e-10
R03 N02 N03 4.73e-03
C04 N03 N04 1.39e-04
R04 N03 N04 2.58e+01
C05 N04 N05 1.91e-04
R05 N04 N05 3.11e+00
C06 N05 N06 1.40e-04
R06 N05 N06 6.27e-01
C07 N06 N07 1.38e-04
R07 N06 N07 9.63e-02
C08 N07 N08 1.69e-04
R08 N07 N08 1.69e-02
C09 N08 N09 7.53e-05
R09 N08 N09 7.04e-03
L10 N09 N10 2.48e-11
R10 N09 N10 6.67e-02
L11 N10 N11 2.16e-10
R11 N10 N11 3.55e-02
C12 N11 N12 2.86e-06
L12 N11 N12 6.02e-11
R12 N11 N12 1.59e-02
C13 N12 N13 2.04e-06
L13 N12 N13 3.90e-11
R13 N12 N13 1.56e-02
C14 N13 N14 1.87e-11
L14 N13 N14 6.02e-11
R14 N13 N14 6.09e+00
C15 N14 Port2 3.00e-12
L15 N14 Port2 1.02e-10
R15 N14 Port2 2.12e+01
.ENDS GGM21BR71E105KA56

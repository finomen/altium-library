*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A563KA01 Port1 Port2
C01 Port1 N01 5.70e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.15e-10
R03 N02 N03 3.58e-02
C04 N03 N04 7.54e-06
R04 N03 N04 7.59e+02
C05 N04 N05 1.03e-05
R05 N04 N05 7.95e+01
C06 N05 N06 7.75e-06
R06 N05 N06 9.78e+00
C07 N06 N07 7.20e-06
R07 N06 N07 9.78e-01
C08 N07 N08 5.79e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.77e-06
R09 N08 N09 2.39e-02
L10 N09 N10 8.76e-11
R10 N09 N10 8.89e-02
C11 N10 N11 4.23e-07
L11 N10 N11 1.93e-11
R11 N10 N11 1.99e-02
C12 N11 N12 7.34e-08
L12 N11 N12 2.88e-11
R12 N11 N12 2.78e-02
C13 N12 N13 1.30e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.28e+01
C14 N13 Port2 1.41e-12
L14 N13 Port2 2.59e-10
R14 N13 Port2 2.69e+01
.ENDS GCJ21BR72A563KA01

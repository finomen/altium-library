*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GRT21BR72A473KE01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR72A473KE01 Port1 Port2
C01 Port1 N01 4.79e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 1.20e-10
R03 N02 N03 1.87e-02
C04 N03 N04 4.66e-06
R04 N03 N04 1.98e+02
C05 N04 N05 5.61e-06
R05 N04 N05 1.46e+01
C06 N05 N06 7.00e-06
R06 N05 N06 1.57e+00
C07 N06 N07 6.35e-06
R07 N06 N07 3.32e-01
C08 N07 N08 3.80e-06
R08 N07 N08 1.01e-01
C09 N08 N09 2.38e-06
R09 N08 N09 2.43e-02
L10 N09 N10 8.71e-11
R10 N09 N10 1.21e-01
C11 N10 N11 2.07e-07
L11 N10 N11 3.55e-11
R11 N10 N11 5.63e-02
C12 N11 N12 5.80e-08
L12 N11 N12 3.96e-11
R12 N11 N12 6.78e-02
C13 N12 N13 1.16e-11
L13 N12 N13 9.07e-11
R13 N12 N13 1.07e+01
C14 N13 Port2 1.70e-12
L14 N13 Port2 1.58e-10
R14 N13 Port2 2.85e+01
.ENDS GRT21BR72A473KE01

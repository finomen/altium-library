*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :LLL219R71C224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL219R71C224MA01 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 6.06e-11
R03 N02 N03 4.93e-03
C04 N03 N04 2.62e-05
R04 N03 N04 1.52e+02
C05 N04 N05 3.62e-05
R05 N04 N05 1.87e+01
C06 N05 N06 3.62e-05
R06 N05 N06 2.70e+00
C07 N06 N07 3.18e-05
R07 N06 N07 5.90e-01
C08 N07 N08 2.54e-05
R08 N07 N08 7.93e-02
C09 N08 N09 2.41e-05
R09 N08 N09 1.38e-02
C10 N09 N10 2.66e-05
R10 N09 N10 3.22e-03
L11 N10 N11 7.01e-11
R11 N10 N11 4.63e-02
L12 N11 N12 6.85e-12
R12 N11 N12 4.40e-02
C13 N12 N13 3.69e-07
L13 N12 N13 4.06e-11
R13 N12 N13 4.28e-02
C14 N13 N14 1.68e-07
L14 N13 N14 3.22e-11
R14 N13 N14 3.32e-02
C15 N14 Port2 5.63e-12
L15 N14 Port2 7.66e-11
R15 N14 Port2 1.47e+01
.ENDS LLL219R71C224MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCJ219R71H393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H393KA01 Port1 Port2
C01 Port1 N01 3.96e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 7.29e-02
C04 N03 N04 5.60e-06
R04 N03 N04 7.86e+02
C05 N04 N05 6.11e-06
R05 N04 N05 1.22e+02
C06 N05 N06 5.10e-06
R06 N05 N06 1.22e+01
C07 N06 N07 7.79e-06
R07 N06 N07 9.02e-01
C08 N07 N08 6.10e-06
R08 N07 N08 3.51e-01
C09 N08 N09 2.30e-06
R09 N08 N09 1.14e-01
C10 N09 N10 4.48e-06
R10 N09 N10 8.31e-03
L11 N10 N11 1.57e-10
R11 N10 N11 1.89e-01
C12 N11 N12 2.05e-07
L12 N11 N12 1.91e-11
R12 N11 N12 3.12e-02
C13 N12 N13 6.36e-08
L13 N12 N13 2.37e-11
R13 N12 N13 5.05e-02
C14 N13 N14 1.06e-10
L14 N13 N14 6.70e-11
R14 N13 N14 1.06e+00
C15 N14 Port2 1.26e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 2.03e+01
.ENDS GCJ219R71H393KA01

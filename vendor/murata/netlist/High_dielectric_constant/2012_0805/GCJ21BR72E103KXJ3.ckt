*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E103KXJ3
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E103KXJ3 Port1 Port2
C01 Port1 N01 9.99e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.65e-10
R03 N02 N03 8.16e-02
C04 N03 N04 9.93e-07
R04 N03 N04 1.95e+03
C05 N04 N05 1.26e-06
R05 N04 N05 3.13e+02
C06 N05 N06 1.04e-06
R06 N05 N06 7.21e+01
C07 N06 N07 9.70e-07
R07 N06 N07 1.39e+01
C08 N07 N08 7.11e-07
R08 N07 N08 3.02e+00
C09 N08 N09 8.88e-07
R09 N08 N09 4.01e-01
C10 N09 N10 4.77e-07
R10 N09 N10 1.02e-01
L11 N10 N11 4.90e-11
R11 N10 N11 1.66e-01
L12 N11 N12 3.26e-11
R12 N11 N12 6.99e-02
C13 N12 N13 2.97e-08
L13 N12 N13 1.85e-11
R13 N12 N13 5.20e-02
C14 N13 Port2 1.91e-11
L14 N13 Port2 9.14e-11
R14 N13 Port2 4.11e+00
.ENDS GCJ21BR72E103KXJ3

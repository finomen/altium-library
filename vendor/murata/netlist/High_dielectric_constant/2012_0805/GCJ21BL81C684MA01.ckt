*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/6.80e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C684MA01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C684MA01 Port1 Port2
C01 Port1 N01 6.67e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.70e-10
R03 N02 N03 1.08e-02
C04 N03 N04 7.91e-05
R04 N03 N04 4.67e+01
C05 N04 N05 9.57e-05
R05 N04 N05 5.62e+00
C06 N05 N06 9.32e-05
R06 N05 N06 7.24e-01
C07 N06 N07 8.79e-05
R07 N06 N07 1.05e-01
C08 N07 N08 8.97e-05
R08 N07 N08 1.51e-02
C09 N08 N09 6.37e-05
R09 N08 N09 6.56e-03
L10 N09 N10 1.73e-11
R10 N09 N10 4.01e-02
L11 N10 N11 2.25e-10
R11 N10 N11 3.83e-02
C12 N11 N12 3.19e-06
L12 N11 N12 3.38e-11
R12 N11 N12 1.18e-02
C13 N12 N13 1.47e-06
L13 N12 N13 3.19e-11
R13 N12 N13 1.38e-02
C14 N13 N14 1.64e-11
L14 N13 N14 7.50e-11
R14 N13 N14 9.30e+00
C15 N14 Port2 1.90e-12
L15 N14 Port2 1.66e-10
R15 N14 Port2 2.63e+01
.ENDS GCJ21BL81C684MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCE21BR72A273KA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A273KA01 Port1 Port2
C01 Port1 N01 2.74e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.03e-10
R03 N02 N03 2.97e-02
C04 N03 N04 3.13e-06
R04 N03 N04 1.10e+03
C05 N04 N05 4.87e-06
R05 N04 N05 1.17e+02
C06 N05 N06 3.49e-06
R06 N05 N06 2.19e+01
C07 N06 N07 3.33e-06
R07 N06 N07 2.34e+00
C08 N07 N08 2.73e-06
R08 N07 N08 3.46e-01
C09 N08 N09 2.74e-06
R09 N08 N09 8.26e-02
C10 N09 N10 2.49e-06
R10 N09 N10 2.04e-02
L11 N10 N11 9.32e-11
R11 N10 N11 1.15e-01
C12 N11 N12 1.29e-07
L12 N11 N12 2.24e-11
R12 N11 N12 4.34e-02
C13 N12 N13 4.28e-08
L13 N12 N13 2.58e-11
R13 N12 N13 6.96e-02
C14 N13 N14 1.02e-11
L14 N13 N14 1.62e-10
R14 N13 N14 1.98e+01
C15 N14 Port2 2.38e-12
L15 N14 Port2 2.34e-10
R15 N14 Port2 2.38e+01
.ENDS GCE21BR72A273KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ216R72A152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.09e-01
C04 N03 N04 1.37e-07
R04 N03 N04 2.24e+04
C05 N04 N05 2.47e-07
R05 N04 N05 1.82e+03
C06 N05 N06 2.33e-07
R06 N05 N06 1.99e+02
C07 N06 N07 1.86e-07
R07 N06 N07 2.51e+01
C08 N07 N08 1.31e-07
R08 N07 N08 3.30e+00
C09 N08 N09 8.04e-08
R09 N08 N09 5.37e-01
C10 N09 N10 3.03e-08
R10 N09 N10 2.14e-01
C11 N10 N11 5.84e-08
L11 N10 N11 2.31e-12
R11 N10 N11 1.36e-02
C12 N11 N12 9.17e-10
L12 N11 N12 3.32e-11
R12 N11 N12 2.54e-01
C13 N12 N13 4.32e-11
L13 N12 N13 8.43e-11
R13 N12 N13 1.56e+00
C14 N13 Port2 1.97e-12
L14 N13 Port2 2.32e-10
R14 N13 Port2 1.57e+01
.ENDS GCJ216R72A152KA01

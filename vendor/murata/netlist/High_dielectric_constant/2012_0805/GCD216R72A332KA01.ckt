*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCD216R72A332KA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R72A332KA01 Port1 Port2
C01 Port1 N01 3.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 1.17e-01
C04 N03 N04 5.14e-07
R04 N03 N04 3.97e+03
C05 N04 N05 6.63e-07
R05 N04 N05 3.23e+02
C06 N05 N06 5.96e-07
R06 N05 N06 5.00e+01
C07 N06 N07 4.40e-07
R07 N06 N07 8.48e+00
C08 N07 N08 3.21e-07
R08 N07 N08 1.16e+00
C09 N08 N09 2.42e-07
R09 N08 N09 2.39e-01
C10 N09 N10 9.67e-08
R10 N09 N10 7.24e-02
C11 N10 N11 2.11e-08
L11 N10 N11 9.57e-12
R11 N10 N11 6.13e-02
C12 N11 N12 1.88e-09
L12 N11 N12 3.62e-11
R12 N11 N12 2.16e-01
C13 N12 N13 4.25e-11
L13 N12 N13 1.10e-10
R13 N12 N13 1.58e+00
C14 N13 N14 4.96e-12
L14 N13 N14 1.13e-10
R14 N13 N14 1.52e+01
C15 N14 Port2 3.40e-12
L15 N14 Port2 9.51e-11
R15 N14 Port2 1.93e+01
.ENDS GCD216R72A332KA01

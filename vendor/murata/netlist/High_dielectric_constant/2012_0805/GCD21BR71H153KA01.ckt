*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCD21BR71H153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR71H153KA01 Port1 Port2
C01 Port1 N01 1.47e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 3.87e-02
C04 N03 N04 1.55e-06
R04 N03 N04 2.57e+03
C05 N04 N05 4.13e-06
R05 N04 N05 2.19e+02
C06 N05 N06 2.04e-06
R06 N05 N06 6.76e+01
C07 N06 N07 1.83e-06
R07 N06 N07 9.12e+00
C08 N07 N08 1.34e-06
R08 N07 N08 1.27e+00
C09 N08 N09 1.06e-06
R09 N08 N09 1.92e-01
C10 N09 N10 7.75e-07
R10 N09 N10 3.71e-02
L11 N10 N11 3.61e-11
R11 N10 N11 9.31e-02
C12 N11 N12 8.24e-08
L12 N11 N12 1.26e-11
R12 N11 N12 3.49e-02
C13 N12 N13 1.26e-08
L13 N12 N13 2.55e-11
R13 N12 N13 7.75e-02
C14 N13 N14 9.70e-12
L14 N13 N14 2.41e-10
R14 N13 N14 2.11e+01
C15 N14 N15 5.11e-12
L15 N14 N15 2.04e-10
R15 N14 N15 1.48e+01
C16 N15 Port2 8.72e-12
L16 N15 Port2 4.12e-11
R16 N15 Port2 6.03e+00
.ENDS GCD21BR71H153KA01

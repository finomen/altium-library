*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ21BR71H105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H105KA01 Port1 Port2
C01 Port1 N01 9.60e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.84e-10
R03 N02 N03 6.33e-03
C04 N03 N04 2.62e-04
R04 N03 N04 2.35e+00
C05 N04 N05 2.41e-04
R05 N04 N05 6.18e-01
C06 N05 N06 2.28e-04
R06 N05 N06 1.35e-01
C07 N06 N07 2.09e-04
R07 N06 N07 2.84e-02
C08 N07 N08 1.31e-04
R08 N07 N08 6.67e-03
L09 N08 N09 2.40e-11
R09 N08 N09 7.63e-02
L10 N09 N10 2.20e-10
R10 N09 N10 4.25e-02
C11 N10 N11 2.69e-06
L11 N10 N11 6.92e-11
R11 N10 N11 1.82e-02
C12 N11 N12 1.66e-06
L12 N11 N12 5.14e-11
R12 N11 N12 1.91e-02
C13 N12 N13 2.48e-11
L13 N12 N13 3.63e-11
R13 N12 N13 4.35e+00
C14 N13 Port2 3.86e-12
L14 N13 Port2 7.17e-11
R14 N13 Port2 1.21e+01
.ENDS GCJ21BR71H105KA01

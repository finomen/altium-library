*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ21BC72A105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BC72A105KE11 Port1 Port2
C01 Port1 N01 1.07e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.52e-10
R03 N02 N03 7.37e-03
C04 N03 N04 1.13e-05
R04 N03 N04 6.77e+02
C05 N04 N05 1.08e-04
R05 N04 N05 6.82e+00
C06 N05 N06 7.89e-05
R06 N05 N06 1.11e+00
C07 N06 N07 7.86e-05
R07 N06 N07 1.04e-01
C08 N07 N08 4.71e-05
R08 N07 N08 1.41e-02
L09 N08 N09 3.39e-11
R09 N08 N09 5.22e-02
L10 N09 N10 2.64e-10
R10 N09 N10 3.98e-02
C11 N10 N11 2.90e-06
L11 N10 N11 6.21e-11
R11 N10 N11 1.44e-02
C12 N11 N12 2.01e-06
L12 N11 N12 3.86e-11
R12 N11 N12 1.26e-02
C13 N12 N13 8.30e-12
L13 N12 N13 8.90e-11
R13 N12 N13 5.94e+00
C14 N13 Port2 6.93e-12
L14 N13 Port2 4.53e-11
R14 N13 Port2 1.15e+01
.ENDS GRJ21BC72A105KE11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCE21BR72A153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A153KA01 Port1 Port2
C01 Port1 N01 1.44e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.43e-10
R03 N02 N03 8.09e-02
C04 N03 N04 1.82e-06
R04 N03 N04 2.03e+03
C05 N04 N05 2.66e-06
R05 N04 N05 2.17e+02
C06 N05 N06 2.29e-06
R06 N05 N06 4.98e+01
C07 N06 N07 1.67e-06
R07 N06 N07 8.14e+00
C08 N07 N08 1.21e-06
R08 N07 N08 1.09e+00
C09 N08 N09 7.03e-07
R09 N08 N09 1.78e-01
L10 N09 N10 3.06e-11
R10 N09 N10 1.04e-01
C11 N10 N11 7.32e-08
L11 N10 N11 1.40e-11
R11 N10 N11 3.21e-02
C12 N11 N12 7.11e-09
L12 N11 N12 4.17e-11
R12 N11 N12 9.80e-02
C13 N12 N13 1.09e-11
L13 N12 N13 2.04e-10
R13 N12 N13 1.60e+01
C14 N13 N14 4.54e-12
L14 N13 N14 1.98e-10
R14 N13 N14 1.48e+01
C15 N14 Port2 4.43e-12
L15 N14 Port2 7.10e-11
R15 N14 Port2 9.78e+00
.ENDS GCE21BR72A153KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/50[V]
* Murata P/N :GCD216R71H392KA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H392KA01 Port1 Port2
C01 Port1 N01 3.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 9.08e-02
C04 N03 N04 4.93e-07
R04 N03 N04 3.57e+03
C05 N04 N05 5.58e-07
R05 N04 N05 2.36e+02
C06 N05 N06 4.87e-07
R06 N05 N06 2.36e+01
C07 N06 N07 3.83e-07
R07 N06 N07 2.67e+00
C08 N07 N08 3.14e-07
R08 N07 N08 4.13e-01
C09 N08 N09 2.21e-07
R09 N08 N09 1.08e-01
C10 N09 N10 6.48e-08
R10 N09 N10 5.61e-02
L11 N10 N11 1.25e-10
R11 N10 N11 1.27e+00
C12 N11 N12 1.58e-08
L12 N11 N12 1.50e-11
R12 N11 N12 8.79e-02
C13 N12 N13 2.52e-09
L13 N12 N13 3.25e-11
R13 N12 N13 1.97e-01
C14 N13 N14 8.51e-12
L14 N13 N14 5.74e-11
R14 N13 N14 9.45e+00
C15 N14 Port2 4.37e-12
L15 N14 Port2 8.10e-11
R15 N14 Port2 1.57e+01
.ENDS GCD216R71H392KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ21BR71A106ME01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71A106ME01 Port1 Port2
C01 Port1 N01 6.15e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.11e-10
R03 N02 N03 6.40e-03
C04 N03 N04 2.14e-04
R04 N03 N04 1.60e+01
C05 N04 N05 2.29e-04
R05 N04 N05 1.74e+00
C06 N05 N06 2.30e-04
R06 N05 N06 2.31e-01
C07 N06 N07 1.96e-04
R07 N06 N07 3.78e-02
C08 N07 N08 1.07e-04
R08 N07 N08 7.18e-03
L09 N08 N09 2.22e-11
R09 N08 N09 8.83e-02
L10 N09 N10 4.96e-11
R10 N09 N10 2.78e-02
L11 N10 N11 3.36e-10
R11 N10 N11 1.78e-02
C12 N11 N12 1.89e-05
L12 N11 N12 6.81e-11
R12 N11 N12 4.80e-03
C13 N12 N13 1.16e-05
L13 N12 N13 5.24e-11
R13 N12 N13 5.50e-03
C14 N13 N14 1.66e-11
L14 N13 N14 5.46e-11
R14 N13 N14 5.87e+00
C15 N14 Port2 1.73e-11
L15 N14 Port2 2.30e-11
R15 N14 Port2 5.22e+00
.ENDS GCJ21BR71A106ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCE21BR71H563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H563KA01 Port1 Port2
C01 Port1 N01 5.59e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.88e-10
R03 N02 N03 2.06e-02
C04 N03 N04 6.48e-06
R04 N03 N04 5.75e+02
C05 N04 N05 1.04e-05
R05 N04 N05 5.49e+01
C06 N05 N06 7.75e-06
R06 N05 N06 1.07e+01
C07 N06 N07 6.06e-06
R07 N06 N07 1.41e+00
C08 N07 N08 4.61e-06
R08 N07 N08 2.04e-01
C09 N08 N09 3.82e-06
R09 N08 N09 2.71e-02
L10 N09 N10 1.12e-10
R10 N09 N10 9.20e-02
C11 N10 N11 2.93e-07
L11 N10 N11 2.20e-11
R11 N10 N11 3.79e-02
C12 N11 N12 6.95e-08
L12 N11 N12 3.92e-11
R12 N11 N12 6.64e-02
C13 N12 N13 1.09e-11
L13 N12 N13 1.29e-10
R13 N12 N13 1.46e+01
C14 N13 Port2 3.27e-12
L14 N13 Port2 1.69e-10
R14 N13 Port2 1.93e+01
.ENDS GCE21BR71H563KA01

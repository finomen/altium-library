*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-02[uF]/16[V]
* Murata P/N :LLL215R71C223MA11
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R71C223MA11 Port1 Port2
C01 Port1 N01 2.36e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 5.91e-11
R03 N02 N03 1.78e-02
C04 N03 N04 3.07e-06
R04 N03 N04 1.20e+03
C05 N04 N05 5.80e-06
R05 N04 N05 1.51e+02
C06 N05 N06 4.29e-06
R06 N05 N06 4.78e+01
C07 N06 N07 3.83e-06
R07 N06 N07 1.05e+01
C08 N07 N08 6.05e-06
R08 N07 N08 1.62e+00
C09 N08 N09 2.62e-06
R09 N08 N09 7.69e-01
C10 N09 N10 2.19e-06
R10 N09 N10 1.14e-01
C11 N10 N11 1.35e-06
R11 N10 N11 2.63e-02
C12 N11 N12 3.75e-08
L12 N11 N12 1.56e-11
R12 N11 N12 5.62e-02
C13 N12 N13 1.17e-08
L13 N12 N13 1.43e-11
R13 N12 N13 5.93e-02
C14 N13 N14 2.13e-10
L14 N13 N14 4.02e-11
R14 N13 N14 3.02e-01
C15 N14 Port2 6.16e-12
L15 N14 Port2 4.99e-11
R15 N14 Port2 6.77e+00
.ENDS LLL215R71C223MA11

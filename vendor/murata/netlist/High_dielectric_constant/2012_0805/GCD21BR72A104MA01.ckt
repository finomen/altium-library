*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCD21BR72A104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR72A104MA01 Port1 Port2
C01 Port1 N01 1.00e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 2.09e-10
R03 N02 N03 9.83e-03
C04 N03 N04 1.17e-05
R04 N03 N04 3.40e+02
C05 N04 N05 1.53e-05
R05 N04 N05 4.09e+01
C06 N05 N06 1.28e-05
R06 N05 N06 7.61e+00
C07 N06 N07 1.05e-05
R07 N06 N07 9.32e-01
C08 N07 N08 7.79e-06
R08 N07 N08 1.18e-01
C09 N08 N09 5.88e-06
R09 N08 N09 1.43e-02
L10 N09 N10 1.88e-10
R10 N09 N10 1.03e-01
L11 N10 N11 2.14e-12
R11 N10 N11 9.26e-03
C12 N11 N12 2.84e-07
L12 N11 N12 5.41e-11
R12 N11 N12 6.94e-02
C13 N12 N13 1.79e-07
L13 N12 N13 3.93e-11
R13 N12 N13 6.44e-02
C14 N13 N14 1.37e-11
L14 N13 N14 5.41e-11
R14 N13 N14 5.80e+00
C15 N14 Port2 5.32e-12
L15 N14 Port2 5.50e-11
R15 N14 Port2 7.02e+00
.ENDS GCD21BR72A104MA01

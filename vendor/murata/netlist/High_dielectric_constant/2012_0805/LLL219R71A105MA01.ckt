*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :LLL219R71A105MA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL219R71A105MA01 Port1 Port2
C01 Port1 N01 9.69e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 6.22e-11
R03 N02 N03 3.02e-03
C04 N03 N04 3.06e-04
R04 N03 N04 5.45e+00
C05 N04 N05 1.67e-04
R05 N04 N05 1.85e+00
C06 N05 N06 1.14e-04
R06 N05 N06 3.22e-01
C07 N06 N07 9.89e-05
R07 N06 N07 4.04e-02
C08 N07 N08 4.42e-05
R08 N07 N08 8.04e-03
L09 N08 N09 1.25e-11
R09 N08 N09 4.60e-02
L10 N09 N10 8.81e-11
R10 N09 N10 2.34e-02
C11 N10 N11 1.65e-06
L11 N10 N11 3.84e-11
R11 N10 N11 2.05e-02
C12 N11 N12 1.11e-06
L12 N11 N12 2.12e-11
R12 N11 N12 1.54e-02
C13 N12 Port2 5.02e-12
L13 N12 Port2 6.85e-11
R13 N12 Port2 1.01e+01
.ENDS LLL219R71A105MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCJ216R72A183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A183KA01 Port1 Port2
C01 Port1 N01 1.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 4.61e-02
C04 N03 N04 2.52e-06
R04 N03 N04 1.36e+03
C05 N04 N05 3.59e-06
R05 N04 N05 1.03e+02
C06 N05 N06 3.08e-06
R06 N05 N06 1.68e+01
C07 N06 N07 2.69e-06
R07 N06 N07 2.02e+00
C08 N07 N08 1.89e-06
R08 N07 N08 3.34e-01
C09 N08 N09 9.78e-07
R09 N08 N09 6.49e-02
L10 N09 N10 2.96e-11
R10 N09 N10 7.06e-02
C11 N10 N11 7.40e-08
L11 N10 N11 1.66e-11
R11 N10 N11 2.81e-02
C12 N11 N12 9.68e-09
L12 N11 N12 3.88e-11
R12 N11 N12 9.67e-02
C13 N12 N13 6.03e-11
L13 N12 N13 1.32e-10
R13 N12 N13 1.38e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.63e-10
R14 N13 Port2 1.96e+01
.ENDS GCJ216R72A183KA01

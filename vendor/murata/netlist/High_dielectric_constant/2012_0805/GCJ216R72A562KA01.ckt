*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCJ216R72A562KA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A562KA01 Port1 Port2
C01 Port1 N01 5.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 1.70e-01
C04 N03 N04 6.72e-07
R04 N03 N04 1.04e+04
C05 N04 N05 8.90e-07
R05 N04 N05 6.11e+02
C06 N05 N06 8.53e-07
R06 N05 N06 5.97e+01
C07 N06 N07 7.22e-07
R07 N06 N07 6.40e+00
C08 N07 N08 5.43e-07
R08 N07 N08 8.62e-01
C09 N08 N09 2.01e-07
R09 N08 N09 2.22e-01
C10 N09 N10 1.69e-08
L10 N09 N10 2.38e-11
R10 N09 N10 8.03e-02
C11 N10 N11 3.46e-09
L11 N10 N11 3.77e-11
R11 N10 N11 1.74e-01
C12 N11 N12 5.33e-11
L12 N11 N12 8.47e-11
R12 N11 N12 1.02e+00
C13 N12 Port2 1.65e-12
L13 N12 Port2 1.87e-10
R13 N12 Port2 2.45e+01
.ENDS GCJ216R72A562KA01

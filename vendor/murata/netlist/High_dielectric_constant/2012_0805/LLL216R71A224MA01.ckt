*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :LLL216R71A224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71A224MA01 Port1 Port2
C01 Port1 N01 2.21e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 5.44e-11
R03 N02 N03 5.50e-03
C04 N03 N04 2.39e-05
R04 N03 N04 1.67e+02
C05 N04 N05 3.28e-05
R05 N04 N05 2.05e+01
C06 N05 N06 3.15e-05
R06 N05 N06 3.10e+00
C07 N06 N07 3.09e-05
R07 N06 N07 6.19e-01
C08 N07 N08 2.36e-05
R08 N07 N08 1.20e-01
C09 N08 N09 2.24e-05
R09 N08 N09 1.94e-02
C10 N09 N10 2.16e-05
R10 N09 N10 4.71e-03
L11 N10 N11 5.10e-11
R11 N10 N11 4.33e-02
C12 N11 N12 4.62e-07
L12 N11 N12 2.16e-11
R12 N11 N12 2.25e-02
C13 N12 N13 1.26e-07
L13 N12 N13 2.51e-11
R13 N12 N13 2.20e-02
C14 N13 Port2 5.02e-12
L14 N13 Port2 9.42e-11
R14 N13 Port2 1.42e+01
.ENDS LLL216R71A224MA01

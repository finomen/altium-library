*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ21BR71C475ME01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71C475ME01 Port1 Port2
C01 Port1 N01 3.22e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.81e-10
R03 N02 N03 7.09e-03
C04 N03 N04 5.33e-05
R04 N03 N04 9.96e+01
C05 N04 N05 1.06e-04
R05 N04 N05 3.92e+00
C06 N05 N06 9.10e-05
R06 N05 N06 4.26e-01
C07 N06 N07 7.82e-05
R07 N06 N07 4.34e-02
C08 N07 N08 8.23e-05
R08 N07 N08 7.17e-03
L09 N08 N09 2.04e-11
R09 N08 N09 1.35e-01
L10 N09 N10 4.34e-11
R10 N09 N10 3.71e-02
L11 N10 N11 2.83e-10
R11 N10 N11 2.59e-02
C12 N11 N12 1.04e-05
L12 N11 N12 5.79e-11
R12 N11 N12 7.20e-03
C13 N12 N13 6.15e-06
L13 N12 N13 4.55e-11
R13 N12 N13 8.18e-03
C14 N13 N14 1.57e-11
L14 N13 N14 5.67e-11
R14 N13 N14 5.79e+00
C15 N14 Port2 8.13e-12
L15 N14 Port2 4.47e-11
R15 N14 Port2 8.78e+00
.ENDS GRJ21BR71C475ME01

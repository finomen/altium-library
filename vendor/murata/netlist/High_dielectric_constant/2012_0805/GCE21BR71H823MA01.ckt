*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCE21BR71H823MA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H823MA01 Port1 Port2
C01 Port1 N01 8.41e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 7.73e-11
R03 N02 N03 1.71e-02
C04 N03 N04 1.12e-05
R04 N03 N04 3.20e+02
C05 N04 N05 1.94e-05
R05 N04 N05 4.03e+01
C06 N05 N06 1.50e-05
R06 N05 N06 1.08e+01
C07 N06 N07 1.26e-05
R07 N06 N07 2.27e+00
C08 N07 N08 8.90e-06
R08 N07 N08 4.22e-01
C09 N08 N09 7.92e-06
R09 N08 N09 5.89e-02
C10 N09 N10 7.39e-06
R10 N09 N10 1.67e-02
L11 N10 N11 8.83e-11
R11 N10 N11 1.12e-01
C12 N11 N12 2.59e-07
L12 N11 N12 4.63e-11
R12 N11 N12 5.44e-02
C13 N12 N13 1.27e-07
L13 N12 N13 4.20e-11
R13 N12 N13 6.41e-02
C14 N13 N14 3.60e-08
L14 N13 N14 4.94e-11
R14 N13 N14 4.30e-02
C15 N14 N15 1.10e-11
L15 N14 N15 9.74e-11
R15 N14 N15 1.15e+01
C16 N15 Port2 1.52e-12
L16 N15 Port2 2.12e-10
R16 N15 Port2 2.86e+01
.ENDS GCE21BR71H823MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :LLL216R71C104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71C104MA01 Port1 Port2
C01 Port1 N01 9.82e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.77e-11
R03 N02 N03 9.57e-03
C04 N03 N04 1.06e-05
R04 N03 N04 3.74e+02
C05 N04 N05 1.68e-05
R05 N04 N05 4.29e+01
C06 N05 N06 1.37e-05
R06 N05 N06 9.61e+00
C07 N06 N07 1.04e-05
R07 N06 N07 1.52e+00
C08 N07 N08 1.09e-05
R08 N07 N08 1.45e-01
C09 N08 N09 7.98e-06
R09 N08 N09 3.08e-02
C10 N09 N10 8.62e-06
R10 N09 N10 4.79e-03
L11 N10 N11 4.94e-11
R11 N10 N11 5.41e-02
L12 N11 N12 2.94e-12
R12 N11 N12 3.62e-02
C13 N12 N13 2.09e-07
L13 N12 N13 1.58e-11
R13 N12 N13 2.23e-02
C14 N13 N14 9.14e-08
L14 N13 N14 1.02e-11
R14 N13 N14 1.73e-02
C15 N14 Port2 5.98e-12
L15 N14 Port2 8.00e-11
R15 N14 Port2 1.25e+01
.ENDS LLL216R71C104MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCD216R71H562KA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H562KA01 Port1 Port2
C01 Port1 N01 5.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 6.71e-02
C04 N03 N04 7.69e-07
R04 N03 N04 5.66e+03
C05 N04 N05 1.12e-06
R05 N04 N05 6.96e+02
C06 N05 N06 8.14e-07
R06 N05 N06 7.63e+01
C07 N06 N07 7.59e-07
R07 N06 N07 7.79e+00
C08 N07 N08 8.15e-07
R08 N07 N08 1.07e+00
C09 N08 N09 4.97e-07
R09 N08 N09 2.77e-01
C10 N09 N10 3.49e-07
R10 N09 N10 6.91e-02
C11 N10 N11 1.70e-07
R11 N10 N11 3.38e-02
L12 N11 N12 1.07e-10
R12 N11 N12 9.21e-01
C13 N12 N13 1.48e-08
L13 N12 N13 2.57e-11
R13 N12 N13 1.02e-01
C14 N13 N14 3.82e-09
L14 N13 N14 3.47e-11
R14 N13 N14 1.86e-01
C15 N14 N15 1.27e-11
L15 N14 N15 3.79e-11
R15 N14 N15 9.05e+00
C16 N15 Port2 4.71e-12
L16 N15 Port2 7.44e-11
R16 N15 Port2 1.48e+01
.ENDS GCD216R71H562KA01

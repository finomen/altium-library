*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-04[uF]/25[V]
* Murata P/N :GCJ216R71E821KA01
* Property : C = 8.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E821KA01 Port1 Port2
C01 Port1 N01 8.32e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 6.95e-01
C04 N03 N04 1.58e-07
R04 N03 N04 1.39e+04
C05 N04 N05 1.41e-07
R05 N04 N05 5.54e+03
C06 N05 N06 1.49e-07
R06 N05 N06 7.65e+02
C07 N06 N07 1.38e-07
R07 N06 N07 1.11e+02
C08 N07 N08 1.16e-07
R08 N07 N08 1.92e+01
C09 N08 N09 7.18e-08
R09 N08 N09 4.19e+00
C10 N09 N10 3.54e-08
R10 N09 N10 9.98e-01
C11 N10 N11 6.83e-09
R11 N10 N11 3.77e-01
L12 N11 N12 1.09e-10
R12 N11 N12 1.10e+00
C13 N12 N13 3.71e-09
L13 N12 N13 1.35e-11
R13 N12 N13 1.80e-01
C14 N13 N14 8.87e-10
L14 N13 N14 1.96e-11
R14 N13 N14 2.83e-01
C15 N14 Port2 3.52e-12
L15 N14 Port2 1.04e-10
R15 N14 Port2 1.52e+01
.ENDS GCJ216R71E821KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7S(-55to125[deg])/1.00e+00[uF]/4[V]
* Murata P/N :LLL215C70G105MA11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215C70G105MA11 Port1 Port2
C01 Port1 N01 9.01e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 6.19e-11
R03 N02 N03 3.43e-03
C04 N03 N04 2.08e-04
R04 N03 N04 7.16e+00
C05 N04 N05 1.23e-04
R05 N04 N05 2.28e+00
C06 N05 N06 9.79e-05
R06 N05 N06 3.50e-01
C07 N06 N07 8.43e-05
R07 N06 N07 4.11e-02
C08 N07 N08 6.38e-05
R08 N07 N08 6.52e-03
L09 N08 N09 1.32e-11
R09 N08 N09 9.41e-02
L10 N09 N10 4.70e-11
R10 N09 N10 2.47e-02
C11 N10 N11 1.32e-06
L11 N10 N11 2.79e-11
R11 N10 N11 1.29e-02
C12 N11 N12 5.71e-07
L12 N11 N12 2.11e-11
R12 N11 N12 1.17e-02
C13 N12 Port2 1.04e-11
L13 N12 Port2 2.44e-11
R13 N12 Port2 4.93e+00
.ENDS LLL215C70G105MA11

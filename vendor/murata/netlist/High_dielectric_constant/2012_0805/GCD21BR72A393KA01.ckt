*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCD21BR72A393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR72A393KA01 Port1 Port2
C01 Port1 N01 4.01e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.10e-11
R03 N02 N03 1.88e-02
C04 N03 N04 5.09e-06
R04 N03 N04 7.82e+02
C05 N04 N05 8.56e-06
R05 N04 N05 9.85e+01
C06 N05 N06 5.59e-06
R06 N05 N06 2.47e+01
C07 N06 N07 5.27e-06
R07 N06 N07 3.11e+00
C08 N07 N08 4.35e-06
R08 N07 N08 4.50e-01
C09 N08 N09 3.93e-06
R09 N08 N09 8.38e-02
C10 N09 N10 2.75e-06
R10 N09 N10 1.84e-02
L11 N10 N11 1.01e-10
R11 N10 N11 1.15e-01
C12 N11 N12 1.53e-07
L12 N11 N12 3.33e-11
R12 N11 N12 6.85e-02
C13 N12 N13 5.46e-08
L13 N12 N13 3.87e-11
R13 N12 N13 8.55e-02
C14 N13 N14 7.91e-12
L14 N13 N14 1.46e-10
R14 N13 N14 1.72e+01
C15 N14 Port2 1.51e-12
L15 N14 Port2 2.12e-10
R15 N14 Port2 2.90e+01
.ENDS GCD21BR72A393KA01

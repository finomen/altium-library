*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :LLL215R71C473MA11
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R71C473MA11 Port1 Port2
C01 Port1 N01 4.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 8.75e-11
R03 N02 N03 1.35e-02
C04 N03 N04 7.96e-06
R04 N03 N04 4.64e+02
C05 N04 N05 7.88e-06
R05 N04 N05 1.04e+02
C06 N05 N06 6.88e-06
R06 N05 N06 1.65e+01
C07 N06 N07 7.05e-06
R07 N06 N07 2.67e+00
C08 N07 N08 5.50e-06
R08 N07 N08 4.30e-01
C09 N08 N09 5.28e-06
R09 N08 N09 6.47e-02
C10 N09 N10 3.04e-06
R10 N09 N10 1.77e-02
L11 N10 N11 2.73e-11
R11 N10 N11 8.97e-02
C12 N11 N12 7.31e-08
L12 N11 N12 1.54e-11
R12 N11 N12 3.29e-02
C13 N12 N13 2.37e-08
L13 N12 N13 1.25e-11
R13 N12 N13 2.87e-02
C14 N13 Port2 9.34e-12
L14 N13 Port2 3.55e-11
R14 N13 Port2 4.75e+00
.ENDS LLL215R71C473MA11

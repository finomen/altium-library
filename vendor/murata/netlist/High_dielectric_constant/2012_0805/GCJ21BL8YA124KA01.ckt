*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.20e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA124KA01
* Property : C = 1.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA124KA01 Port1 Port2
C01 Port1 N01 1.28e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 1.57e-10
R03 N02 N03 1.52e-02
C04 N03 N04 1.75e-05
R04 N03 N04 3.17e+02
C05 N04 N05 1.82e-05
R05 N04 N05 4.38e+01
C06 N05 N06 1.65e-05
R06 N05 N06 4.91e+00
C07 N06 N07 1.63e-05
R07 N06 N07 5.15e-01
C08 N07 N08 1.17e-05
R08 N07 N08 8.30e-02
C09 N08 N09 7.64e-06
R09 N08 N09 1.05e-02
L10 N09 N10 1.37e-10
R10 N09 N10 7.79e-02
C11 N10 N11 4.62e-07
L11 N10 N11 3.55e-11
R11 N10 N11 2.38e-02
C12 N11 N12 1.88e-07
L12 N11 N12 3.20e-11
R12 N11 N12 2.91e-02
C13 N12 N13 1.14e-11
L13 N12 N13 1.31e-10
R13 N12 N13 1.11e+01
C14 N13 Port2 2.82e-12
L14 N13 Port2 1.54e-10
R14 N13 Port2 2.66e+01
.ENDS GCJ21BL8YA124KA01

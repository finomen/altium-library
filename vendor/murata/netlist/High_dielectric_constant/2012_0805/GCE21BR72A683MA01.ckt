*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCE21BR72A683MA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A683MA01 Port1 Port2
C01 Port1 N01 6.67e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.09e-10
R03 N02 N03 1.97e-02
C04 N03 N04 7.28e-06
R04 N03 N04 5.47e+02
C05 N04 N05 1.27e-05
R05 N04 N05 5.73e+01
C06 N05 N06 8.38e-06
R06 N05 N06 1.12e+01
C07 N06 N07 7.48e-06
R07 N06 N07 1.34e+00
C08 N07 N08 6.65e-06
R08 N07 N08 1.82e-01
C09 N08 N09 6.53e-06
R09 N08 N09 3.33e-02
C10 N09 N10 8.99e-06
R10 N09 N10 1.07e-02
L11 N10 N11 7.55e-11
R11 N10 N11 7.81e-02
C12 N11 N12 3.83e-07
L12 N11 N12 2.31e-11
R12 N11 N12 2.64e-02
C13 N12 N13 1.08e-07
L13 N12 N13 3.40e-11
R13 N12 N13 5.29e-02
C14 N13 N14 3.31e-08
L14 N13 N14 2.91e-11
R14 N13 N14 3.29e-02
C15 N14 N15 1.17e-11
L15 N14 N15 1.10e-10
R15 N14 N15 1.36e+01
C16 N15 Port2 1.75e-12
L16 N15 Port2 2.21e-10
R16 N15 Port2 3.26e+01
.ENDS GCE21BR72A683MA01

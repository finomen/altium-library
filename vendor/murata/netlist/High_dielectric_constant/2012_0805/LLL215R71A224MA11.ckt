*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-01[uF]/10[V]
* Murata P/N :LLL215R71A224MA11
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R71A224MA11 Port1 Port2
C01 Port1 N01 2.17e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 7.82e-11
R03 N02 N03 5.48e-03
C04 N03 N04 2.44e-05
R04 N03 N04 1.63e+02
C05 N04 N05 3.08e-05
R05 N04 N05 2.53e+01
C06 N05 N06 2.43e-05
R06 N05 N06 3.74e+00
C07 N06 N07 3.00e-05
R07 N06 N07 4.39e-01
C08 N07 N08 2.36e-05
R08 N07 N08 8.35e-02
C09 N08 N09 2.06e-05
R09 N08 N09 1.37e-02
C10 N09 N10 2.88e-05
R10 N09 N10 2.48e-03
L11 N10 N11 5.15e-12
R11 N10 N11 5.61e-02
L12 N11 N12 4.87e-11
R12 N11 N12 4.48e-02
C13 N12 N13 3.61e-07
L13 N12 N13 2.35e-11
R13 N12 N13 2.42e-02
C14 N13 N14 1.38e-07
L14 N13 N14 2.07e-11
R14 N13 N14 2.29e-02
C15 N14 Port2 1.28e-11
L15 N14 Port2 2.84e-11
R15 N14 Port2 4.28e+00
.ENDS LLL215R71A224MA11

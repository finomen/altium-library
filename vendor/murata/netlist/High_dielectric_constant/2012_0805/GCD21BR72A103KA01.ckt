*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCD21BR72A103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR72A103KA01 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 9.85e-11
R03 N02 N03 4.79e-02
C04 N03 N04 1.50e-06
R04 N03 N04 2.28e+03
C05 N04 N05 2.11e-06
R05 N04 N05 2.75e+02
C06 N05 N06 1.61e-06
R06 N05 N06 5.12e+01
C07 N06 N07 1.33e-06
R07 N06 N07 6.58e+00
C08 N07 N08 1.21e-06
R08 N07 N08 8.48e-01
C09 N08 N09 6.40e-07
R09 N08 N09 1.83e-01
C10 N09 N10 4.22e-07
R10 N09 N10 3.69e-02
L11 N10 N11 9.20e-11
R11 N10 N11 3.72e-01
C12 N11 N12 3.66e-08
L12 N11 N12 2.87e-11
R12 N11 N12 9.01e-02
C13 N12 N13 1.17e-08
L13 N12 N13 3.43e-11
R13 N12 N13 1.25e-01
C14 N13 N14 3.37e-11
L14 N13 N14 1.43e-10
R14 N13 N14 3.12e+00
C15 N14 N15 4.66e-12
L15 N14 N15 1.25e-10
R15 N14 N15 1.11e+01
C16 N15 Port2 4.44e-12
L16 N15 Port2 8.26e-11
R16 N15 Port2 1.05e+01
.ENDS GCD21BR72A103KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :LLL216R71H223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71H223MA01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 1.88e-02
C04 N03 N04 2.59e-06
R04 N03 N04 1.32e+03
C05 N04 N05 7.35e-06
R05 N04 N05 1.18e+02
C06 N05 N06 3.70e-06
R06 N05 N06 5.15e+01
C07 N06 N07 4.77e-06
R07 N06 N07 1.05e+01
C08 N07 N08 4.25e-06
R08 N07 N08 3.10e+00
C09 N08 N09 2.59e-06
R09 N08 N09 7.95e-01
C10 N09 N10 1.78e-06
R10 N09 N10 1.31e-01
C11 N10 N11 1.15e-06
R11 N10 N11 2.86e-02
L12 N11 N12 4.00e-11
R12 N11 N12 1.31e-01
C13 N12 N13 3.14e-08
L13 N12 N13 2.37e-11
R13 N12 N13 8.51e-02
C14 N13 N14 1.78e-08
L14 N13 N14 1.31e-11
R14 N13 N14 5.61e-02
C15 N14 Port2 3.65e-12
L15 N14 Port2 5.94e-11
R15 N14 Port2 8.18e+00
.ENDS LLL216R71H223MA01

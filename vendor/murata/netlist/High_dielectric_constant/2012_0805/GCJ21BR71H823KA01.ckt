*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/8.20e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H823KA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H823KA01 Port1 Port2
C01 Port1 N01 8.22e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.41e-10
R03 N02 N03 2.29e-02
C04 N03 N04 1.09e-05
R04 N03 N04 6.44e+02
C05 N04 N05 1.36e-05
R05 N04 N05 6.01e+01
C06 N05 N06 1.18e-05
R06 N05 N06 6.90e+00
C07 N06 N07 1.07e-05
R07 N06 N07 7.56e-01
C08 N07 N08 8.74e-06
R08 N07 N08 9.04e-02
C09 N08 N09 8.05e-06
R09 N08 N09 1.69e-02
L10 N09 N10 1.27e-10
R10 N09 N10 8.60e-02
L11 N10 N11 7.88e-12
R11 N10 N11 3.18e-02
C12 N11 N12 4.70e-07
L12 N11 N12 2.56e-11
R12 N11 N12 2.82e-02
C13 N12 N13 1.14e-07
L13 N12 N13 3.75e-11
R13 N12 N13 3.58e-02
C14 N13 N14 9.33e-12
L14 N13 N14 1.12e-10
R14 N13 N14 1.21e+01
C15 N14 Port2 1.91e-12
L15 N14 Port2 1.78e-10
R15 N14 Port2 2.92e+01
.ENDS GCJ21BR71H823KA01

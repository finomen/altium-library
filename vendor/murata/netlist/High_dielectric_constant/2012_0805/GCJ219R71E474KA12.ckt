*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ219R71E474KA12
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E474KA12 Port1 Port2
C01 Port1 N01 4.82e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.79e-10
R03 N02 N03 1.93e-02
C04 N03 N04 5.94e-05
R04 N03 N04 5.36e+01
C05 N04 N05 1.16e-04
R05 N04 N05 5.36e+00
C06 N05 N06 6.53e-05
R06 N05 N06 1.51e+00
C07 N06 N07 6.48e-05
R07 N06 N07 1.78e-01
C08 N07 N08 7.69e-05
R08 N07 N08 2.09e-02
C09 N08 N09 3.42e-05
R09 N08 N09 1.20e-02
L10 N09 N10 2.51e-11
R10 N09 N10 4.92e-02
L11 N10 N11 2.37e-10
R11 N10 N11 4.57e-02
C12 N11 N12 3.83e-06
L12 N11 N12 1.77e-11
R12 N11 N12 9.47e-03
C13 N12 N13 1.03e-06
L13 N12 N13 2.83e-11
R13 N12 N13 1.67e-02
C14 N13 N14 1.80e-11
L14 N13 N14 3.94e-11
R14 N13 N14 5.80e+00
C15 N14 Port2 1.87e-12
L15 N14 Port2 1.24e-10
R15 N14 Port2 1.41e+01
.ENDS GCJ219R71E474KA12

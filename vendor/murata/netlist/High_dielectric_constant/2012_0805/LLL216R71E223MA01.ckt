*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :LLL216R71E223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71E223MA01 Port1 Port2
C01 Port1 N01 2.16e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.26e-11
R03 N02 N03 2.03e-02
C04 N03 N04 3.38e-06
R04 N03 N04 1.18e+03
C05 N04 N05 3.76e-06
R05 N04 N05 2.40e+02
C06 N05 N06 3.16e-06
R06 N05 N06 4.47e+01
C07 N06 N07 3.01e-06
R07 N06 N07 5.76e+00
C08 N07 N08 2.47e-06
R08 N07 N08 7.86e-01
C09 N08 N09 1.99e-06
R09 N08 N09 1.26e-01
C10 N09 N10 1.27e-06
R10 N09 N10 2.59e-02
L11 N10 N11 3.22e-11
R11 N10 N11 1.43e-01
C12 N11 N12 3.98e-08
L12 N11 N12 1.55e-11
R12 N11 N12 4.24e-02
C13 N12 N13 1.26e-08
L13 N12 N13 1.38e-11
R13 N12 N13 4.57e-02
C14 N13 Port2 5.26e-12
L14 N13 Port2 8.69e-11
R14 N13 Port2 1.25e+01
.ENDS LLL216R71E223MA01

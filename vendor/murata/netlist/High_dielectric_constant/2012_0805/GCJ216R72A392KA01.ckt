*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ216R72A392KA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A392KA01 Port1 Port2
C01 Port1 N01 4.12e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 3.83e-01
C04 N03 N04 4.85e-07
R04 N03 N04 8.21e+03
C05 N04 N05 6.60e-07
R05 N04 N05 6.52e+02
C06 N05 N06 5.89e-07
R06 N05 N06 9.86e+01
C07 N06 N07 5.35e-07
R07 N06 N07 9.64e+00
C08 N07 N08 5.82e-07
R08 N07 N08 1.69e+00
C09 N08 N09 3.18e-07
R09 N08 N09 4.85e-01
C10 N09 N10 1.21e-07
R10 N09 N10 1.11e-01
L11 N10 N11 1.13e-10
R11 N10 N11 5.78e-01
C12 N11 N12 4.80e-08
L12 N11 N12 5.57e-12
R12 N11 N12 4.40e-02
C13 N12 N13 7.35e-09
L13 N12 N13 1.25e-11
R13 N12 N13 1.11e-01
C14 N13 N14 3.40e-10
L14 N13 N14 1.31e-11
R14 N13 N14 4.21e-01
C15 N14 Port2 1.26e-12
L15 N14 Port2 1.93e-10
R15 N14 Port2 1.94e+01
.ENDS GCJ216R72A392KA01

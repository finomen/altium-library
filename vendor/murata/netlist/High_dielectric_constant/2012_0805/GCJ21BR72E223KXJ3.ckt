*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E223KXJ3
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E223KXJ3 Port1 Port2
C01 Port1 N01 2.20e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 3.64e-10
R03 N02 N03 5.09e-02
C04 N03 N04 2.24e-06
R04 N03 N04 7.97e+02
C05 N04 N05 2.27e-06
R05 N04 N05 2.37e+02
C06 N05 N06 1.95e-06
R06 N05 N06 5.07e+01
C07 N06 N07 1.87e-06
R07 N06 N07 1.04e+01
C08 N07 N08 1.63e-06
R08 N07 N08 2.17e+00
C09 N08 N09 1.29e-06
R09 N08 N09 5.16e-01
C10 N09 N10 1.23e-06
R10 N09 N10 7.34e-02
L11 N10 N11 4.93e-11
R11 N10 N11 1.25e-01
L12 N11 N12 3.70e-11
R12 N11 N12 4.74e-02
C13 N12 N13 5.60e-08
L13 N12 N13 2.12e-11
R13 N12 N13 4.20e-02
C14 N13 N14 2.46e-07
L14 N13 N14 3.02e-12
R14 N13 N14 1.21e-02
C15 N14 Port2 3.75e-11
L15 N14 Port2 4.70e-11
R15 N14 Port2 1.62e+00
.ENDS GCJ21BR72E223KXJ3

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCJ21BR72A683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72A683KA01 Port1 Port2
C01 Port1 N01 6.69e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.75e-10
R03 N02 N03 2.51e-02
C04 N03 N04 9.70e-06
R04 N03 N04 4.10e+02
C05 N04 N05 1.65e-05
R05 N04 N05 4.50e+01
C06 N05 N06 1.23e-05
R06 N05 N06 9.40e+00
C07 N06 N07 9.31e-06
R07 N06 N07 1.39e+00
C08 N07 N08 1.07e-05
R08 N07 N08 1.41e-01
C09 N08 N09 8.01e-06
R09 N08 N09 3.58e-02
C10 N09 N10 5.84e-06
R10 N09 N10 1.33e-02
L11 N10 N11 8.52e-11
R11 N10 N11 1.24e-01
C12 N11 N12 2.92e-07
L12 N11 N12 4.28e-11
R12 N11 N12 3.86e-02
C13 N12 N13 3.11e-08
L13 N12 N13 7.05e-11
R13 N12 N13 4.48e-02
C14 N13 N14 1.47e-11
L14 N13 N14 6.42e-11
R14 N13 N14 8.41e+00
C15 N14 Port2 2.24e-12
L15 N14 Port2 1.52e-10
R15 N14 Port2 2.06e+01
.ENDS GCJ21BR72A683KA01

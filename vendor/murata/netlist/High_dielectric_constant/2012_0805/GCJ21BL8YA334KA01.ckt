*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.30e-01[uF]/35[V]
* Murata P/N :GCJ21BL8YA334KA01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8YA334KA01 Port1 Port2
C01 Port1 N01 3.23e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.17e-10
R03 N02 N03 1.43e-02
C04 N03 N04 4.04e-05
R04 N03 N04 9.85e+01
C05 N04 N05 5.36e-05
R05 N04 N05 1.08e+01
C06 N05 N06 4.15e-05
R06 N05 N06 1.53e+00
C07 N06 N07 3.53e-05
R07 N06 N07 1.60e-01
C08 N07 N08 1.94e-05
R08 N07 N08 2.27e-02
L09 N08 N09 2.17e-10
R09 N08 N09 5.38e-02
L10 N09 N10 1.59e-11
R10 N09 N10 4.72e-02
C11 N10 N11 1.20e-06
L11 N10 N11 4.33e-11
R11 N10 N11 2.07e-02
C12 N11 N12 8.08e-07
L12 N11 N12 2.71e-11
R12 N11 N12 2.30e-02
C13 N12 N13 2.62e-11
L13 N12 N13 4.49e-11
R13 N12 N13 6.04e+00
C14 N13 Port2 1.79e-12
L14 N13 Port2 1.85e-10
R14 N13 Port2 2.93e+01
.ENDS GCJ21BL8YA334KA01

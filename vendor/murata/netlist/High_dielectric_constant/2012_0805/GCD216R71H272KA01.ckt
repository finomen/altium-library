*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCD216R71H272KA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H272KA01 Port1 Port2
C01 Port1 N01 2.92e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.01e-10
R03 N02 N03 9.55e-02
C04 N03 N04 2.55e-07
R04 N03 N04 1.73e+04
C05 N04 N05 4.42e-07
R05 N04 N05 4.56e+02
C06 N05 N06 4.45e-07
R06 N05 N06 4.88e+01
C07 N06 N07 7.14e-07
R07 N06 N07 6.43e+00
C08 N07 N08 2.82e-07
R08 N07 N08 2.69e+00
C09 N08 N09 2.01e-07
R09 N08 N09 4.52e-01
C10 N09 N10 1.12e-07
R10 N09 N10 1.18e-01
C11 N10 N11 3.10e-08
R11 N10 N11 5.89e-02
L12 N11 N12 1.08e-10
R12 N11 N12 8.91e-01
C13 N12 N13 1.07e-08
L13 N12 N13 1.80e-11
R13 N12 N13 9.61e-02
C14 N13 N14 2.31e-09
L14 N13 N14 2.95e-11
R14 N13 N14 2.07e-01
C15 N14 N15 1.20e-11
L15 N14 N15 5.24e-11
R15 N14 N15 1.07e+01
C16 N15 Port2 2.27e-12
L16 N15 Port2 1.71e-10
R16 N15 Port2 1.95e+01
.ENDS GCD216R71H272KA01

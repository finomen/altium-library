*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/3.90e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H393KA01 Port1 Port2
C01 Port1 N01 3.98e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.23e-10
R03 N02 N03 3.31e-02
C04 N03 N04 6.30e-06
R04 N03 N04 6.43e+02
C05 N04 N05 9.03e-06
R05 N04 N05 9.95e+01
C06 N05 N06 6.10e-06
R06 N05 N06 1.61e+01
C07 N06 N07 5.65e-06
R07 N06 N07 1.73e+00
C08 N07 N08 2.36e-05
R08 N07 N08 1.47e-01
C09 N08 N09 4.87e-06
R09 N08 N09 1.46e-01
C10 N09 N10 3.25e-06
R10 N09 N10 4.00e-02
C11 N10 N11 1.28e-05
R11 N10 N11 2.24e-03
L12 N11 N12 1.19e-10
R12 N11 N12 1.47e-01
C13 N12 N13 2.85e-07
L13 N12 N13 1.54e-11
R13 N12 N13 2.43e-02
C14 N13 N14 4.58e-08
L14 N13 N14 3.62e-11
R14 N13 N14 5.42e-02
C15 N14 N15 6.53e-11
L15 N14 N15 1.48e-10
R15 N14 N15 1.97e+00
C16 N15 Port2 4.20e-12
L16 N15 Port2 1.51e-10
R16 N15 Port2 1.31e+01
.ENDS GCJ21BL81H393KA01

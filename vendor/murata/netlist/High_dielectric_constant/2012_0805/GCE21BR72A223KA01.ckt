*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCE21BR72A223KA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A223KA01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 9.70e-11
R03 N02 N03 3.74e-02
C04 N03 N04 2.17e-06
R04 N03 N04 1.84e+03
C05 N04 N05 3.94e-06
R05 N04 N05 1.21e+02
C06 N05 N06 3.96e-06
R06 N05 N06 2.21e+01
C07 N06 N07 3.32e-06
R07 N06 N07 5.67e+00
C08 N07 N08 2.26e-06
R08 N07 N08 1.10e+00
C09 N08 N09 1.86e-06
R09 N08 N09 1.83e-01
C10 N09 N10 1.29e-06
R10 N09 N10 5.70e-02
L11 N10 N11 6.36e-11
R11 N10 N11 1.22e-01
C12 N11 N12 9.19e-08
L12 N11 N12 2.02e-11
R12 N11 N12 3.53e-02
C13 N12 N13 2.22e-08
L13 N12 N13 3.25e-11
R13 N12 N13 9.54e-02
C14 N13 N14 1.04e-11
L14 N13 N14 1.64e-10
R14 N13 N14 1.77e+01
C15 N14 N15 5.51e-12
L15 N14 N15 1.47e-10
R15 N14 N15 1.53e+01
C16 N15 Port2 2.27e-12
L16 N15 Port2 1.41e-10
R16 N15 Port2 1.25e+01
.ENDS GCE21BR72A223KA01

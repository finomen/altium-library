*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ21BR71E105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71E105KE11 Port1 Port2
C01 Port1 N01 1.04e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.40e-10
R03 N02 N03 1.81e-02
C04 N03 N04 1.07e-05
R04 N03 N04 7.03e+02
C05 N04 N05 1.31e-04
R05 N04 N05 5.27e+00
C06 N05 N06 1.03e-04
R06 N05 N06 6.02e-01
C07 N06 N07 9.70e-05
R07 N06 N07 5.71e-02
C08 N07 N08 7.03e-05
R08 N07 N08 8.13e-03
L09 N08 N09 2.41e-11
R09 N08 N09 6.59e-02
L10 N09 N10 2.93e-10
R10 N09 N10 4.20e-02
C11 N10 N11 4.18e-06
L11 N10 N11 3.54e-11
R11 N10 N11 1.21e-02
C12 N11 N12 2.88e-06
L12 N11 N12 2.38e-11
R12 N11 N12 1.26e-02
C13 N12 N13 1.18e-11
L13 N12 N13 9.15e-11
R13 N12 N13 7.62e+00
C14 N13 Port2 3.77e-12
L14 N13 Port2 9.23e-11
R14 N13 Port2 1.96e+01
.ENDS GRJ21BR71E105KE11

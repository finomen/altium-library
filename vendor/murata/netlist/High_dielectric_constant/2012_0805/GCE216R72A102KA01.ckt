*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCE216R72A102KA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A102KA01 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.67e-11
R03 N02 N03 3.11e-01
C04 N03 N04 1.02e-07
R04 N03 N04 1.39e+04
C05 N04 N05 1.64e-07
R05 N04 N05 5.54e+02
C06 N05 N06 1.39e-07
R06 N05 N06 6.51e+01
C07 N06 N07 9.91e-08
R07 N06 N07 8.62e+00
C08 N07 N08 4.31e-08
R08 N07 N08 1.53e+00
C09 N08 N09 1.28e-08
R09 N08 N09 3.23e-01
L10 N09 N10 5.08e-11
R10 N09 N10 2.88e+00
C11 N10 N11 1.78e-11
L11 N10 N11 1.84e-10
R11 N10 N11 3.29e+00
C12 N11 N12 6.07e-12
L12 N11 N12 1.34e-10
R12 N11 N12 1.40e+01
C13 N12 Port2 1.74e-12
L13 N12 Port2 1.77e-10
R13 N12 Port2 1.86e+01
.ENDS GCE216R72A102KA01

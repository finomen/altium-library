*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/4.70e+00[uF]/35[V]
* Murata P/N :GCH21BC7YA475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BC7YA475KE11 Port1 Port2
C01 Port1 N01 3.79e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.01e-10
R03 N02 N03 3.31e-03
C04 N03 N04 1.67e-04
R04 N03 N04 2.30e+01
C05 N04 N05 2.18e-04
R05 N04 N05 2.19e+00
C06 N05 N06 2.00e-04
R06 N05 N06 3.58e-01
C07 N06 N07 1.98e-04
R07 N06 N07 5.43e-02
C08 N07 N08 2.02e-04
R08 N07 N08 1.06e-02
C09 N08 N09 1.40e-04
R09 N08 N09 3.89e-03
L10 N09 N10 1.51e-11
R10 N09 N10 1.11e-01
L11 N10 N11 2.36e-10
R11 N10 N11 2.31e-02
L12 N11 N12 2.27e-11
R12 N11 N12 2.26e-02
C13 N12 N13 7.26e-06
L13 N12 N13 8.65e-11
R13 N12 N13 1.10e-02
C14 N13 N14 5.36e-06
L14 N13 N14 5.15e-11
R14 N13 N14 8.50e-03
C15 N14 Port2 8.66e-12
L15 N14 Port2 5.91e-11
R15 N14 Port2 1.17e+01
.ENDS GCH21BC7YA475KE11

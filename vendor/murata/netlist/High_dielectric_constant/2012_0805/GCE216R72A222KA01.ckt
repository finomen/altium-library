*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE216R72A222KA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A222KA01 Port1 Port2
C01 Port1 N01 2.22e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.97e-11
R03 N02 N03 1.46e-01
C04 N03 N04 1.81e-07
R04 N03 N04 1.80e+04
C05 N04 N05 3.38e-07
R05 N04 N05 6.10e+02
C06 N05 N06 3.52e-07
R06 N05 N06 6.10e+01
C07 N06 N07 3.03e-07
R07 N06 N07 9.67e+00
C08 N07 N08 1.79e-07
R08 N07 N08 1.95e+00
C09 N08 N09 1.02e-07
R09 N08 N09 3.73e-01
C10 N09 N10 3.00e-08
R10 N09 N10 1.18e-01
L11 N10 N11 1.75e-10
R11 N10 N11 1.67e+00
C12 N11 N12 2.09e-09
L12 N11 N12 2.09e-11
R12 N11 N12 1.90e-01
C13 N12 N13 7.83e-12
L13 N12 N13 7.83e-11
R13 N12 N13 1.18e+01
C14 N13 Port2 1.73e-12
L14 N13 Port2 1.96e-10
R14 N13 Port2 2.79e+01
.ENDS GCE216R72A222KA01

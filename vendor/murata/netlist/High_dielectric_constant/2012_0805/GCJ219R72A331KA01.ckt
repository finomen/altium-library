*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-04[uF]/100[V]
* Murata P/N :GCJ219R72A331KA01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A331KA01 Port1 Port2
C01 Port1 N01 3.58e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.87e-11
R03 N02 N03 4.73e-01
C04 N03 N04 2.71e-08
R04 N03 N04 1.86e+05
C05 N04 N05 4.16e-08
R05 N04 N05 2.39e+04
C06 N05 N06 5.45e-08
R06 N05 N06 1.62e+03
C07 N06 N07 4.61e-08
R07 N06 N07 1.86e+02
C08 N07 N08 7.73e-08
R08 N07 N08 1.87e+01
C09 N08 N09 2.78e-08
R09 N08 N09 8.73e+00
C10 N09 N10 9.64e-09
R10 N09 N10 1.81e+00
C11 N10 N11 1.86e-09
R11 N10 N11 5.93e-01
C12 N11 N12 3.46e-09
L12 N11 N12 6.96e-12
R12 N11 N12 2.05e-01
C13 N12 N13 5.71e-10
L13 N12 N13 1.94e-11
R13 N12 N13 5.29e-01
C14 N13 N14 4.21e-12
L14 N13 N14 2.34e-10
R14 N13 N14 1.15e+01
C15 N14 Port2 1.39e-12
L15 N14 Port2 2.01e-10
R15 N14 Port2 1.77e+01
.ENDS GCJ219R72A331KA01

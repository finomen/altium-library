*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E472KXJ1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E472KXJ1 Port1 Port2
C01 Port1 N01 4.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.01e-10
R03 N02 N03 1.63e-01
C04 N03 N04 4.37e-07
R04 N03 N04 3.98e+03
C05 N04 N05 5.54e-07
R05 N04 N05 5.79e+02
C06 N05 N06 4.72e-07
R06 N05 N06 1.25e+02
C07 N06 N07 4.28e-07
R07 N06 N07 2.30e+01
C08 N07 N08 3.37e-07
R08 N07 N08 4.39e+00
C09 N08 N09 2.54e-07
R09 N08 N09 7.76e-01
C10 N09 N10 1.64e-07
R10 N09 N10 1.07e-01
L11 N10 N11 1.61e-10
R11 N10 N11 3.04e+00
L12 N11 N12 4.44e-11
R12 N11 N12 4.01e-01
C13 N12 Port2 3.20e-09
L13 N12 Port2 4.43e-11
R13 N12 Port2 1.76e-01
.ENDS GCJ21AR72E472KXJ1

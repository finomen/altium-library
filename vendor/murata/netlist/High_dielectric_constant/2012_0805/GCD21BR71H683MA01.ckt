*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-02[uF]/50[V]
* Murata P/N :GCD21BR71H683MA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR71H683MA01 Port1 Port2
C01 Port1 N01 6.43e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.18e-10
R03 N02 N03 1.59e-02
C04 N03 N04 8.53e-06
R04 N03 N04 4.66e+02
C05 N04 N05 1.22e-05
R05 N04 N05 7.39e+01
C06 N05 N06 8.94e-06
R06 N05 N06 1.58e+01
C07 N06 N07 7.67e-06
R07 N06 N07 2.08e+00
C08 N07 N08 6.50e-06
R08 N07 N08 3.70e-01
C09 N08 N09 5.00e-06
R09 N08 N09 5.40e-02
C10 N09 N10 6.66e-06
R10 N09 N10 9.71e-03
L11 N10 N11 1.24e-10
R11 N10 N11 8.95e-02
C12 N11 N12 2.95e-07
L12 N11 N12 2.88e-11
R12 N11 N12 5.08e-02
C13 N12 N13 9.89e-08
L13 N12 N13 3.57e-11
R13 N12 N13 6.32e-02
C14 N13 N14 1.24e-11
L14 N13 N14 1.13e-10
R14 N13 N14 1.52e+01
C15 N14 Port2 1.91e-12
L15 N14 Port2 2.33e-10
R15 N14 Port2 3.13e+01
.ENDS GCD21BR71H683MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/250[V]
* Murata P/N :GCJ21AR72E102KXJ1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21AR72E102KXJ1 Port1 Port2
C01 Port1 N01 1.07e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.68e-10
R03 N02 N03 3.58e-01
C04 N03 N04 1.27e-07
R04 N03 N04 1.33e+04
C05 N04 N05 1.28e-07
R05 N04 N05 3.41e+03
C06 N05 N06 1.12e-07
R06 N05 N06 7.18e+02
C07 N06 N07 1.09e-07
R07 N06 N07 1.42e+02
C08 N07 N08 9.20e-08
R08 N07 N08 3.06e+01
C09 N08 N09 6.82e-08
R09 N08 N09 6.69e+00
C10 N09 N10 5.01e-08
R10 N09 N10 1.43e+00
C11 N10 N11 2.00e-08
R11 N10 N11 4.09e-01
L12 N11 N12 1.46e-10
R12 N11 N12 3.47e+00
L13 N12 N13 4.65e-11
R13 N12 N13 1.16e+00
C14 N13 N14 8.09e-10
L14 N13 N14 1.70e-11
R14 N13 N14 4.37e-01
C15 N14 Port2 6.59e-11
L15 N14 Port2 1.11e-10
R15 N14 Port2 2.73e+00
.ENDS GCJ21AR72E102KXJ1

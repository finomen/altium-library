*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ21BR71A106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71A106KE01 Port1 Port2
C01 Port1 N01 6.56e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.67e-10
R03 N02 N03 1.19e-02
C04 N03 N04 1.32e-04
R04 N03 N04 4.01e+01
C05 N04 N05 2.39e-04
R05 N04 N05 2.54e+00
C06 N05 N06 2.03e-04
R06 N05 N06 3.96e-01
C07 N06 N07 1.72e-04
R07 N06 N07 4.65e-02
C08 N07 N08 1.64e-04
R08 N07 N08 8.09e-03
L09 N08 N09 1.39e-11
R09 N08 N09 8.39e-02
L10 N09 N10 5.05e-11
R10 N09 N10 4.37e-02
L11 N10 N11 3.12e-10
R11 N10 N11 2.08e-02
C12 N11 N12 2.32e-05
L12 N11 N12 5.11e-11
R12 N11 N12 4.64e-03
C13 N12 N13 1.35e-05
L13 N12 N13 4.19e-11
R13 N12 N13 5.36e-03
C14 N13 N14 1.28e-11
L14 N13 N14 5.64e-11
R14 N13 N14 4.71e+00
C15 N14 Port2 1.18e-11
L15 N14 Port2 2.91e-11
R15 N14 Port2 1.21e+01
.ENDS GRJ21BR71A106KE01

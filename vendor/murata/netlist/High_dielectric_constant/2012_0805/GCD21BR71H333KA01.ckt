*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-02[uF]/50[V]
* Murata P/N :GCD21BR71H333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR71H333KA01 Port1 Port2
C01 Port1 N01 3.23e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 2.00e-02
C04 N03 N04 3.45e-06
R04 N03 N04 1.07e+03
C05 N04 N05 8.42e-06
R05 N04 N05 8.52e+01
C06 N05 N06 4.36e-06
R06 N05 N06 3.47e+01
C07 N06 N07 3.89e-06
R07 N06 N07 4.05e+00
C08 N07 N08 2.72e-06
R08 N07 N08 6.08e-01
C09 N08 N09 2.38e-06
R09 N08 N09 7.92e-02
C10 N09 N10 2.05e-06
R10 N09 N10 1.36e-02
L11 N10 N11 9.76e-11
R11 N10 N11 1.09e-01
C12 N11 N12 1.46e-07
L12 N11 N12 2.46e-11
R12 N11 N12 6.01e-02
C13 N12 N13 4.18e-08
L13 N12 N13 3.54e-11
R13 N12 N13 8.10e-02
C14 N13 N14 1.12e-11
L14 N13 N14 1.17e-10
R14 N13 N14 1.41e+01
C15 N14 Port2 1.35e-12
L15 N14 Port2 2.46e-10
R15 N14 Port2 2.44e+01
.ENDS GCD21BR71H333KA01

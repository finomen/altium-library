*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/50[V]
* Murata P/N :GCJ219R71H334MA12
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71H334MA12 Port1 Port2
C01 Port1 N01 3.29e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.63e-10
R03 N02 N03 1.79e-02
C04 N03 N04 3.83e-05
R04 N03 N04 1.04e+02
C05 N04 N05 6.61e-05
R05 N04 N05 1.02e+01
C06 N05 N06 4.71e-05
R06 N05 N06 2.07e+00
C07 N06 N07 4.08e-05
R07 N06 N07 3.78e-01
C08 N07 N08 2.83e-05
R08 N07 N08 4.43e-02
C09 N08 N09 1.95e-05
R09 N08 N09 1.01e-02
L10 N09 N10 2.15e-11
R10 N09 N10 8.13e-02
L11 N10 N11 1.85e-10
R11 N10 N11 5.97e-02
C12 N11 N12 1.36e-06
L12 N11 N12 3.23e-11
R12 N11 N12 1.79e-02
C13 N12 N13 4.67e-07
L13 N12 N13 3.99e-11
R13 N12 N13 2.35e-02
C14 N13 N14 2.99e-11
L14 N13 N14 3.32e-11
R14 N13 N14 5.53e+00
C15 N14 Port2 2.35e-12
L15 N14 Port2 1.23e-10
R15 N14 Port2 1.82e+01
.ENDS GCJ219R71H334MA12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE21BR72A103KA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A103KA01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 7.76e-11
R03 N02 N03 8.37e-02
C04 N03 N04 1.08e-06
R04 N03 N04 3.70e+03
C05 N04 N05 3.85e-06
R05 N04 N05 1.99e+02
C06 N05 N06 1.70e-06
R06 N05 N06 8.87e+01
C07 N06 N07 1.63e-06
R07 N06 N07 1.12e+01
C08 N07 N08 1.35e-06
R08 N07 N08 1.69e+00
C09 N08 N09 7.40e-07
R09 N08 N09 3.27e-01
C10 N09 N10 5.10e-07
R10 N09 N10 6.10e-02
L11 N10 N11 5.98e-11
R11 N10 N11 1.37e-01
C12 N11 N12 5.75e-08
L12 N11 N12 1.88e-11
R12 N11 N12 7.58e-02
C13 N12 N13 9.85e-09
L13 N12 N13 4.11e-11
R13 N12 N13 1.12e-01
C14 N13 N14 2.92e-11
L14 N13 N14 1.77e-10
R14 N13 N14 3.20e+00
C15 N14 Port2 1.68e-12
L15 N14 Port2 2.46e-10
R15 N14 Port2 3.24e+01
.ENDS GCE21BR72A103KA01

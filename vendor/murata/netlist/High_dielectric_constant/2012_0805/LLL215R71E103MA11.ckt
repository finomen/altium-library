*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :LLL215R71E103MA11
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R71E103MA11 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 6.36e-11
R03 N02 N03 2.80e-02
C04 N03 N04 1.22e-06
R04 N03 N04 3.03e+03
C05 N04 N05 2.77e-06
R05 N04 N05 3.03e+02
C06 N05 N06 1.42e-06
R06 N05 N06 1.07e+02
C07 N06 N07 1.43e-06
R07 N06 N07 1.18e+01
C08 N07 N08 1.24e-06
R08 N07 N08 1.87e+00
C09 N08 N09 1.05e-06
R09 N08 N09 2.97e-01
C10 N09 N10 6.34e-07
R10 N09 N10 8.06e-02
C11 N10 N11 6.85e-07
R11 N10 N11 1.30e-02
L12 N11 N12 2.46e-11
R12 N11 N12 1.30e-01
C13 N12 N13 1.67e-08
L13 N12 N13 1.31e-11
R13 N12 N13 6.83e-02
C14 N13 N14 5.58e-09
L14 N13 N14 1.10e-11
R14 N13 N14 6.64e-02
C15 N14 Port2 7.37e-12
L15 N14 Port2 3.92e-11
R15 N14 Port2 7.44e+00
.ENDS LLL215R71E103MA11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCE21BR71H183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR71H183KA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.93e-10
R03 N02 N03 3.75e-02
C04 N03 N04 2.10e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.63e-06
R05 N04 N05 1.85e+02
C06 N05 N06 2.64e-06
R06 N05 N06 3.14e+01
C07 N06 N07 2.19e-06
R07 N06 N07 4.15e+00
C08 N07 N08 1.54e-06
R08 N07 N08 6.31e-01
C09 N08 N09 1.01e-06
R09 N08 N09 1.02e-01
L10 N09 N10 8.58e-11
R10 N09 N10 1.05e-01
C11 N10 N11 1.74e-07
L11 N10 N11 8.15e-12
R11 N10 N11 2.43e-02
C12 N11 N12 2.43e-08
L12 N11 N12 2.09e-11
R12 N11 N12 5.99e-02
C13 N12 N13 9.88e-12
L13 N12 N13 1.84e-10
R13 N12 N13 1.73e+01
C14 N13 N14 5.21e-12
L14 N13 N14 1.48e-10
R14 N13 N14 1.53e+01
C15 N14 Port2 6.82e-12
L15 N14 Port2 4.33e-11
R15 N14 Port2 7.75e+00
.ENDS GCE21BR71H183KA01

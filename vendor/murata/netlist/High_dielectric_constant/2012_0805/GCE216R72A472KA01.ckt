*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCE216R72A472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE216R72A472KA01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 8.02e-02
C04 N03 N04 4.77e-07
R04 N03 N04 6.77e+03
C05 N04 N05 7.34e-07
R05 N04 N05 2.63e+02
C06 N05 N06 6.57e-07
R06 N05 N06 2.76e+01
C07 N06 N07 4.91e-07
R07 N06 N07 3.16e+00
C08 N07 N08 3.89e-07
R08 N07 N08 4.09e-01
C09 N08 N09 2.14e-07
R09 N08 N09 1.17e-01
C10 N09 N10 1.16e-07
R10 N09 N10 2.55e-02
L11 N10 N11 1.21e-10
R11 N10 N11 1.04e+00
C12 N11 N12 2.28e-08
L12 N11 N12 1.24e-11
R12 N11 N12 7.35e-02
C13 N12 N13 3.47e-09
L13 N12 N13 2.80e-11
R13 N12 N13 1.86e-01
C14 N13 N14 7.02e-10
L14 N13 N14 6.85e-12
R14 N13 N14 1.59e-01
C15 N14 Port2 3.69e-12
L15 N14 Port2 1.17e-10
R15 N14 Port2 1.61e+01
.ENDS GCE216R72A472KA01

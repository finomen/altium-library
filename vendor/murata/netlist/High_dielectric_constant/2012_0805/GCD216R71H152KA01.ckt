*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCD216R71H152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H152KA01 Port1 Port2
C01 Port1 N01 1.54e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.02e-10
R03 N02 N03 1.63e-01
C04 N03 N04 1.50e-07
R04 N03 N04 1.17e+04
C05 N04 N05 2.38e-07
R05 N04 N05 6.90e+02
C06 N05 N06 2.18e-07
R06 N05 N06 7.56e+01
C07 N06 N07 1.71e-07
R07 N06 N07 9.30e+00
C08 N07 N08 1.18e-07
R08 N07 N08 1.44e+00
C09 N08 N09 5.66e-08
R09 N08 N09 3.28e-01
C10 N09 N10 1.52e-08
R10 N09 N10 1.25e-01
C11 N10 N11 7.34e-10
L11 N10 N11 4.57e-11
R11 N10 N11 3.18e-01
C12 N11 N12 2.66e-11
L12 N11 N12 1.20e-10
R12 N11 N12 2.63e+00
C13 N12 N13 5.45e-12
L13 N12 N13 1.38e-10
R13 N12 N13 1.23e+01
C14 N13 Port2 2.73e-12
L14 N13 Port2 1.52e-10
R14 N13 Port2 1.52e+01
.ENDS GCD216R71H152KA01

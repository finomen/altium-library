*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GR321AD72E153KW01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR321AD72E153KW01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 3.19e-10
R03 N02 N03 2.05e-02
C04 N03 N04 3.84e-06
R04 N03 N04 1.05e+03
C05 N04 N05 6.28e-06
R05 N04 N05 8.87e+01
C06 N05 N06 6.43e-06
R06 N05 N06 1.82e+01
C07 N06 N07 6.10e-06
R07 N06 N07 4.17e+00
C08 N07 N08 5.50e-06
R08 N07 N08 9.46e-01
C09 N08 N09 3.83e-06
R09 N08 N09 2.88e-01
C10 N09 N10 3.56e-06
R10 N09 N10 5.48e-02
L11 N10 N11 2.94e-11
R11 N10 N11 1.06e+00
L12 N11 N12 8.83e-11
R12 N11 N12 2.87e-01
C13 N12 N13 7.50e-08
L13 N12 N13 2.11e-11
R13 N12 N13 8.62e-02
C14 N13 N14 1.36e-08
L14 N13 N14 4.95e-11
R14 N13 N14 1.58e-01
C15 N14 Port2 1.79e-10
L15 N14 Port2 1.29e-11
R15 N14 Port2 6.64e-01
.ENDS GR321AD72E153KW01

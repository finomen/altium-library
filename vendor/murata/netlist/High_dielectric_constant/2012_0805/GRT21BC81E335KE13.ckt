*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/3.30e+00[uF]/25[V]
* Murata P/N :GRT21BC81E335KE13
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BC81E335KE13 Port1 Port2
C01 Port1 N01 2.41e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 1.30e-10
R03 N02 N03 4.64e-03
C04 N03 N04 7.93e-05
R04 N03 N04 1.60e+01
C05 N04 N05 8.65e-05
R05 N04 N05 1.75e+00
C06 N05 N06 7.13e-05
R06 N05 N06 2.83e-01
C07 N06 N07 6.07e-05
R07 N06 N07 4.54e-02
C08 N07 N08 4.49e-05
R08 N07 N08 9.46e-03
L09 N08 N09 2.52e-11
R09 N08 N09 1.95e-01
L10 N09 N10 2.52e-11
R10 N09 N10 3.43e-02
L11 N10 N11 2.04e-10
R11 N10 N11 2.62e-02
C12 N11 N12 7.15e-06
L12 N11 N12 5.23e-11
R12 N11 N12 1.01e-02
C13 N12 N13 3.12e-06
L13 N12 N13 5.62e-11
R13 N12 N13 1.02e-02
C14 N13 N14 1.58e-11
L14 N13 N14 5.24e-11
R14 N13 N14 6.82e+00
C15 N14 Port2 5.84e-12
L15 N14 Port2 5.03e-11
R15 N14 Port2 9.17e+00
.ENDS GRT21BC81E335KE13

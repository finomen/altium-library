*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GC321BD72E223KX03
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC321BD72E223KX03 Port1 Port2
C01 Port1 N01 2.23e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 3.56e-10
R03 N02 N03 1.59e-02
C04 N03 N04 6.06e-06
R04 N03 N04 4.90e+02
C05 N04 N05 8.87e-06
R05 N04 N05 4.07e+01
C06 N05 N06 8.85e-06
R06 N05 N06 7.19e+00
C07 N06 N07 7.80e-06
R07 N06 N07 1.39e+00
C08 N07 N08 6.22e-06
R08 N07 N08 2.59e-01
C09 N08 N09 4.52e-06
R09 N08 N09 4.75e-02
L10 N09 N10 1.02e-10
R10 N09 N10 1.66e-01
C11 N10 N11 1.26e-07
L11 N10 N11 2.30e-11
R11 N10 N11 7.54e-02
C12 N11 N12 2.78e-08
L12 N11 N12 4.46e-11
R12 N11 N12 1.10e-01
C13 N12 Port2 2.78e-11
L13 N12 Port2 5.69e-11
R13 N12 Port2 2.77e+00
.ENDS GC321BD72E223KX03

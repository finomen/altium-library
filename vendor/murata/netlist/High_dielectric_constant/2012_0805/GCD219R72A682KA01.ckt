*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCD219R72A682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD219R72A682KA01 Port1 Port2
C01 Port1 N01 6.94e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 6.75e-02
C04 N03 N04 8.33e-07
R04 N03 N04 1.84e+03
C05 N04 N05 9.93e-07
R05 N04 N05 1.24e+02
C06 N05 N06 9.52e-07
R06 N05 N06 6.65e+00
C07 N06 N07 3.70e-06
R07 N06 N07 5.06e+00
C08 N07 N08 9.45e-07
R08 N07 N08 9.24e-01
C09 N08 N09 4.32e-07
R09 N08 N09 2.59e-01
C10 N09 N10 2.61e-07
R10 N09 N10 4.85e-02
C11 N10 N11 4.14e-08
L11 N10 N11 1.39e-11
R11 N10 N11 6.15e-02
C12 N11 N12 5.82e-09
L12 N11 N12 3.29e-11
R12 N11 N12 1.29e-01
C13 N12 N13 2.52e-11
L13 N12 N13 1.78e-10
R13 N12 N13 2.27e+00
C14 N13 N14 1.03e-11
L14 N13 N14 5.12e-11
R14 N13 N14 8.77e+00
C15 N14 Port2 4.02e-12
L15 N14 Port2 8.72e-11
R15 N14 Port2 1.19e+01
.ENDS GCD219R72A682KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GCD21BR71H563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR71H563KA01 Port1 Port2
C01 Port1 N01 5.31e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.86e-10
R03 N02 N03 1.69e-02
C04 N03 N04 6.43e-06
R04 N03 N04 5.75e+02
C05 N04 N05 1.01e-05
R05 N04 N05 5.75e+01
C06 N05 N06 8.11e-06
R06 N05 N06 1.55e+01
C07 N06 N07 5.90e-06
R07 N06 N07 2.75e+00
C08 N07 N08 4.70e-06
R08 N07 N08 4.07e-01
C09 N08 N09 4.48e-06
R09 N08 N09 6.17e-02
C10 N09 N10 3.35e-06
R10 N09 N10 1.61e-02
L11 N10 N11 9.39e-11
R11 N10 N11 9.77e-02
C12 N11 N12 2.68e-07
L12 N11 N12 2.42e-11
R12 N11 N12 4.11e-02
C13 N12 N13 5.56e-08
L13 N12 N13 4.63e-11
R13 N12 N13 7.27e-02
C14 N13 N14 9.69e-12
L14 N13 N14 1.50e-10
R14 N13 N14 1.87e+01
C15 N14 Port2 3.22e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 2.18e+01
.ENDS GCD21BR71H563KA01

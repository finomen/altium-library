*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-01[uF]/25[V]
* Murata P/N :GCJ219R71E334KA01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R71E334KA01 Port1 Port2
C01 Port1 N01 3.22e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 1.32e-10
R03 N02 N03 1.22e-02
C04 N03 N04 3.76e-05
R04 N03 N04 2.79e+01
C05 N04 N05 4.70e-05
R05 N04 N05 2.79e+00
C06 N05 N06 4.25e-05
R06 N05 N06 4.42e-01
C07 N06 N07 3.75e-05
R07 N06 N07 7.01e-02
C08 N07 N08 2.93e-05
R08 N07 N08 1.54e-02
L09 N08 N09 1.80e-11
R09 N08 N09 7.57e-02
L10 N09 N10 1.35e-10
R10 N09 N10 5.87e-02
C11 N10 N11 1.41e-06
L11 N10 N11 2.88e-11
R11 N10 N11 1.49e-02
C12 N11 N12 3.45e-07
L12 N11 N12 4.88e-11
R12 N11 N12 2.73e-02
C13 N12 N13 1.30e-11
L13 N12 N13 7.46e-11
R13 N12 N13 9.90e+00
C14 N13 Port2 2.34e-12
L14 N13 Port2 1.23e-10
R14 N13 Port2 2.74e+01
.ENDS GCJ219R71E334KA01

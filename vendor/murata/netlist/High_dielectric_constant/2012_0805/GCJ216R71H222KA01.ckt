*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCJ216R71H222KA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H222KA01 Port1 Port2
C01 Port1 N01 2.24e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 1.53e-01
C04 N03 N04 2.46e-07
R04 N03 N04 1.42e+04
C05 N04 N05 4.61e-07
R05 N04 N05 1.15e+03
C06 N05 N06 3.60e-07
R06 N05 N06 1.70e+02
C07 N06 N07 3.04e-07
R07 N06 N07 2.05e+01
C08 N07 N08 2.05e-07
R08 N07 N08 2.81e+00
C09 N08 N09 1.25e-07
R09 N08 N09 4.76e-01
C10 N09 N10 4.63e-08
R10 N09 N10 1.18e-01
C11 N10 N11 1.24e-08
L11 N10 N11 1.03e-11
R11 N10 N11 5.34e-02
C12 N11 N12 7.70e-10
L12 N11 N12 5.00e-11
R12 N11 N12 3.40e-01
C13 N12 N13 3.11e-11
L13 N12 N13 1.06e-10
R13 N12 N13 1.72e+00
C14 N13 Port2 2.29e-12
L14 N13 Port2 2.04e-10
R14 N13 Port2 2.44e+01
.ENDS GCJ216R71H222KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCD216R72A102KA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R72A102KA01 Port1 Port2
C01 Port1 N01 1.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 7.83e-11
R03 N02 N03 2.61e-01
C04 N03 N04 1.06e-07
R04 N03 N04 1.78e+04
C05 N04 N05 1.64e-07
R05 N04 N05 9.57e+02
C06 N05 N06 1.37e-07
R06 N05 N06 1.03e+02
C07 N06 N07 1.19e-07
R07 N06 N07 1.28e+01
C08 N07 N08 8.13e-08
R08 N07 N08 2.16e+00
C09 N08 N09 4.57e-08
R09 N08 N09 5.43e-01
C10 N09 N10 1.50e-08
R10 N09 N10 1.88e-01
L11 N10 N11 3.24e-10
R11 N10 N11 5.43e+00
C12 N11 N12 7.31e-11
L12 N11 N12 5.07e-11
R12 N11 N12 1.20e+00
C13 N12 N13 7.66e-12
L13 N12 N13 1.16e-10
R13 N12 N13 1.04e+01
C14 N13 Port2 8.37e-12
L14 N13 Port2 5.68e-11
R14 N13 Port2 6.17e+00
.ENDS GCD216R72A102KA01

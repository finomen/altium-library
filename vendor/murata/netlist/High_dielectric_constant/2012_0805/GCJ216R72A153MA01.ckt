*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ216R72A153MA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A153MA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.08e-10
R03 N02 N03 1.58e-01
C04 N03 N04 1.75e-06
R04 N03 N04 2.13e+03
C05 N04 N05 2.94e-06
R05 N04 N05 1.82e+02
C06 N05 N06 2.72e-06
R06 N05 N06 3.23e+01
C07 N06 N07 2.20e-06
R07 N06 N07 5.74e+00
C08 N07 N08 1.92e-06
R08 N07 N08 8.30e-01
C09 N08 N09 1.21e-06
R09 N08 N09 1.82e-01
C10 N09 N10 1.13e-06
R10 N09 N10 5.04e-02
L11 N10 N11 4.79e-11
R11 N10 N11 1.93e-01
C12 N11 N12 1.44e-07
L12 N11 N12 5.74e-12
R12 N11 N12 1.01e-02
C13 N12 N13 3.34e-09
L13 N12 N13 6.88e-11
R13 N12 N13 1.75e-01
C14 N13 N14 5.38e-11
L14 N13 N14 1.44e-10
R14 N13 N14 1.79e+00
C15 N14 Port2 1.37e-12
L15 N14 Port2 1.81e-10
R15 N14 Port2 2.52e+01
.ENDS GCJ216R72A153MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCJ216R72A272KA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R72A272KA01 Port1 Port2
C01 Port1 N01 2.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.75e-11
R03 N02 N03 6.11e-01
C04 N03 N04 3.11e-07
R04 N03 N04 8.84e+03
C05 N04 N05 5.07e-07
R05 N04 N05 7.88e+02
C06 N05 N06 5.23e-07
R06 N05 N06 1.11e+02
C07 N06 N07 7.11e-07
R07 N06 N07 1.72e+01
C08 N07 N08 4.01e-07
R08 N07 N08 5.98e+00
C09 N08 N09 4.37e-07
R09 N08 N09 1.34e+00
C10 N09 N10 1.87e-07
R10 N09 N10 6.13e-01
C11 N10 N11 7.62e-08
R11 N10 N11 2.29e-01
L12 N11 N12 4.40e-11
R12 N11 N12 2.74e-01
C13 N12 N13 1.67e-08
L13 N12 N13 1.03e-11
R13 N12 N13 4.74e-02
C14 N13 N14 1.68e-09
L14 N13 N14 3.58e-11
R14 N13 N14 2.14e-01
C15 N14 N15 1.15e-10
L15 N14 N15 3.51e-11
R15 N14 N15 7.48e-01
C16 N15 Port2 1.32e-12
L16 N15 Port2 2.36e-10
R16 N15 Port2 2.74e+01
.ENDS GCJ216R72A272KA01

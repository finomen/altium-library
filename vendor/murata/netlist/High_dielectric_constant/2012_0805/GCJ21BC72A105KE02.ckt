*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ21BC72A105KE02
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BC72A105KE02 Port1 Port2
C01 Port1 N01 9.56e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.06e-10
R03 N02 N03 8.41e-03
C04 N03 N04 1.22e-04
R04 N03 N04 4.02e+00
C05 N04 N05 1.10e-04
R05 N04 N05 6.91e-01
C06 N05 N06 1.38e-04
R06 N05 N06 1.15e-01
C07 N06 N07 1.12e-04
R07 N06 N07 2.66e-02
C08 N07 N08 6.66e-05
R08 N07 N08 8.62e-03
L09 N08 N09 1.16e-11
R09 N08 N09 4.04e-02
L10 N09 N10 2.72e-10
R10 N09 N10 3.90e-02
L11 N10 N11 1.93e-11
R11 N10 N11 3.05e-02
C12 N11 N12 2.63e-06
L12 N11 N12 6.22e-11
R12 N11 N12 1.55e-02
C13 N12 N13 2.01e-06
L13 N12 N13 3.67e-11
R13 N12 N13 1.23e-02
C14 N13 N14 1.91e-11
L14 N13 N14 4.82e-11
R14 N13 N14 5.26e+00
C15 N14 Port2 9.54e-12
L15 N14 Port2 5.34e-11
R15 N14 Port2 5.38e+00
.ENDS GCJ21BC72A105KE02

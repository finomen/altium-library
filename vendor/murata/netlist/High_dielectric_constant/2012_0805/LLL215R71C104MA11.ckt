*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :LLL215R71C104MA11
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R71C104MA11 Port1 Port2
C01 Port1 N01 1.02e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 8.30e-11
R03 N02 N03 7.50e-03
C04 N03 N04 1.19e-05
R04 N03 N04 3.51e+02
C05 N04 N05 1.76e-05
R05 N04 N05 4.42e+01
C06 N05 N06 1.42e-05
R06 N05 N06 8.61e+00
C07 N06 N07 1.25e-05
R07 N06 N07 1.30e+00
C08 N07 N08 1.12e-05
R08 N07 N08 1.69e-01
C09 N08 N09 9.63e-06
R09 N08 N09 3.23e-02
C10 N09 N10 6.59e-06
R10 N09 N10 7.99e-03
L11 N10 N11 4.11e-11
R11 N10 N11 6.94e-02
C12 N11 N12 1.41e-07
L12 N11 N12 2.35e-11
R12 N11 N12 3.28e-02
C13 N12 N13 6.80e-08
L13 N12 N13 1.46e-11
R13 N12 N13 2.67e-02
C14 N13 Port2 9.79e-12
L14 N13 Port2 2.76e-11
R14 N13 Port2 3.27e+00
.ENDS LLL215R71C104MA11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/5.60e-04[uF]/50[V]
* Murata P/N :GCJ216R71H561KA01
* Property : C = 5.60e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H561KA01 Port1 Port2
C01 Port1 N01 5.61e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.79e-11
R03 N02 N03 3.24e-01
C04 N03 N04 4.09e-08
R04 N03 N04 3.67e+04
C05 N04 N05 9.43e-08
R05 N04 N05 1.68e+03
C06 N05 N06 8.19e-08
R06 N05 N06 1.76e+02
C07 N06 N07 6.22e-08
R07 N06 N07 2.16e+01
C08 N07 N08 4.05e-08
R08 N07 N08 3.55e+00
C09 N08 N09 1.65e-08
R09 N08 N09 7.89e-01
C10 N09 N10 3.51e-09
R10 N09 N10 4.10e-01
C11 N10 N11 1.25e-09
L11 N10 N11 1.94e-11
R11 N10 N11 1.93e-01
C12 N11 N12 4.18e-10
L12 N11 N12 2.10e-11
R12 N11 N12 3.83e-01
C13 N12 N13 1.24e-11
L13 N12 N13 6.38e-11
R13 N12 N13 6.44e+00
C14 N13 Port2 6.04e-13
L14 N13 Port2 3.05e-10
R14 N13 Port2 2.95e+01
.ENDS GCJ216R71H561KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/2.70e-02[uF]/50[V]
* Murata P/N :GCJ21BL81H273KA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H273KA01 Port1 Port2
C01 Port1 N01 2.68e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 3.91e-02
C04 N03 N04 2.43e-06
R04 N03 N04 3.61e+03
C05 N04 N05 4.82e-06
R05 N04 N05 1.65e+02
C06 N05 N06 3.87e-06
R06 N05 N06 2.18e+01
C07 N06 N07 4.56e-06
R07 N06 N07 1.61e+00
C08 N07 N08 3.85e-05
R08 N07 N08 6.00e-01
C09 N08 N09 7.29e-06
R09 N08 N09 2.94e-01
C10 N09 N10 2.98e-06
R10 N09 N10 2.03e-01
C11 N10 N11 1.76e-06
R11 N10 N11 4.18e-02
C12 N11 N12 6.29e-06
R12 N11 N12 1.36e-03
L13 N12 N13 1.21e-10
R13 N12 N13 1.54e-01
C14 N13 N14 2.64e-07
L14 N13 N14 1.59e-11
R14 N13 N14 2.48e-02
C15 N14 N15 5.14e-08
L15 N14 N15 3.52e-11
R15 N14 N15 6.32e-02
C16 N15 N16 4.30e-11
L16 N15 N16 1.64e-10
R16 N15 N16 3.18e+00
C17 N16 Port2 1.73e-12
L17 N16 Port2 2.51e-10
R17 N16 Port2 1.29e+01
.ENDS GCJ21BL81H273KA01

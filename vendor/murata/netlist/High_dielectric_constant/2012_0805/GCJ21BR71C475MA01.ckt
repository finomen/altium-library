*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ21BR71C475MA01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71C475MA01 Port1 Port2
C01 Port1 N01 2.93e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.20e-10
R03 N02 N03 5.81e-03
C04 N03 N04 9.96e-05
R04 N03 N04 1.80e+01
C05 N04 N05 1.06e-04
R05 N04 N05 2.01e+00
C06 N05 N06 9.71e-05
R06 N05 N06 2.81e-01
C07 N06 N07 8.09e-05
R07 N06 N07 4.31e-02
C08 N07 N08 5.58e-05
R08 N07 N08 8.03e-03
L09 N08 N09 1.70e-11
R09 N08 N09 6.75e-02
L10 N09 N10 3.44e-11
R10 N09 N10 2.49e-02
L11 N10 N11 2.53e-10
R11 N10 N11 2.37e-02
C12 N11 N12 8.41e-06
L12 N11 N12 5.93e-11
R12 N11 N12 7.06e-03
C13 N12 N13 5.10e-06
L13 N12 N13 4.84e-11
R13 N12 N13 7.03e-03
C14 N13 N14 2.37e-11
L14 N13 N14 5.85e-11
R14 N13 N14 6.78e+00
C15 N14 Port2 2.64e-12
L15 N14 Port2 1.31e-10
R15 N14 Port2 2.25e+01
.ENDS GCJ21BR71C475MA01

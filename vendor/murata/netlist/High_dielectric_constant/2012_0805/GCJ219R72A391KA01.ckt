*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.90e-04[uF]/100[V]
* Murata P/N :GCJ219R72A391KA01
* Property : C = 3.90e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A391KA01 Port1 Port2
C01 Port1 N01 4.10e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.21e-10
R03 N02 N03 4.31e-01
C04 N03 N04 4.29e-08
R04 N03 N04 5.86e+04
C05 N04 N05 6.25e-08
R05 N04 N05 7.20e+03
C06 N05 N06 6.27e-08
R06 N05 N06 5.47e+02
C07 N06 N07 1.48e-07
R07 N06 N07 7.37e+01
C08 N07 N08 5.34e-08
R08 N07 N08 5.22e+01
C09 N08 N09 2.89e-08
R09 N08 N09 9.03e+00
C10 N09 N10 1.36e-08
R10 N09 N10 1.85e+00
C11 N10 N11 2.91e-09
R11 N10 N11 5.73e-01
C12 N11 N12 1.36e-09
L12 N11 N12 1.79e-11
R12 N11 N12 3.60e-01
C13 N12 N13 6.11e-10
L13 N12 N13 2.02e-11
R13 N12 N13 4.34e-01
C14 N13 N14 4.65e-12
L14 N13 N14 2.32e-10
R14 N13 N14 1.17e+01
C15 N14 Port2 3.71e-12
L15 N14 Port2 1.01e-10
R15 N14 Port2 1.36e+01
.ENDS GCJ219R72A391KA01

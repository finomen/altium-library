*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ216R71H102KA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71H102KA01 Port1 Port2
C01 Port1 N01 1.05e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.15e-11
R03 N02 N03 2.70e-01
C04 N03 N04 1.05e-07
R04 N03 N04 2.12e+04
C05 N04 N05 2.30e-07
R05 N04 N05 1.11e+03
C06 N05 N06 1.63e-07
R06 N05 N06 1.85e+02
C07 N06 N07 1.24e-07
R07 N06 N07 2.38e+01
C08 N07 N08 7.59e-08
R08 N07 N08 3.36e+00
C09 N08 N09 5.56e-08
R09 N08 N09 4.58e-01
C10 N09 N10 1.21e-08
R10 N09 N10 2.84e-01
C11 N10 N11 4.85e-10
L11 N10 N11 3.18e-11
R11 N10 N11 3.70e-01
C12 N11 N12 3.71e-11
L12 N11 N12 1.01e-10
R12 N11 N12 2.56e+00
C13 N12 Port2 1.69e-12
L13 N12 Port2 3.39e-10
R13 N12 Port2 2.39e+01
.ENDS GCJ216R71H102KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7S(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCH21BC72A105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH21BC72A105KE11 Port1 Port2
C01 Port1 N01 9.41e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.15e-10
R03 N02 N03 5.63e-03
C04 N03 N04 9.63e-05
R04 N03 N04 1.20e+01
C05 N04 N05 9.32e-05
R05 N04 N05 1.37e+00
C06 N05 N06 9.75e-05
R06 N05 N06 1.93e-01
C07 N06 N07 9.56e-05
R07 N06 N07 2.82e-02
C08 N07 N08 9.23e-05
R08 N07 N08 7.54e-03
C09 N08 N09 9.06e-05
R09 N08 N09 2.18e-03
L10 N09 N10 8.54e-12
R10 N09 N10 7.85e-02
L11 N10 N11 2.54e-11
R11 N10 N11 5.17e-02
L12 N11 N12 2.12e-10
R12 N11 N12 3.83e-02
C13 N12 N13 2.82e-06
L13 N12 N13 5.71e-11
R13 N12 N13 1.52e-02
C14 N13 N14 1.38e-06
L14 N13 N14 5.29e-11
R14 N13 N14 1.37e-02
C15 N14 N15 1.97e-11
L15 N14 N15 5.84e-11
R15 N14 N15 5.66e+00
C16 N15 Port2 2.63e-11
L16 N15 Port2 2.77e-11
R16 N15 Port2 3.25e+00
.ENDS GCH21BC72A105KE11

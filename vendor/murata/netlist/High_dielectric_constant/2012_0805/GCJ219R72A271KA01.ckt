*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-04[uF]/100[V]
* Murata P/N :GCJ219R72A271KA01
* Property : C = 2.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A271KA01 Port1 Port2
C01 Port1 N01 2.73e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 5.14e-01
C04 N03 N04 3.51e-08
R04 N03 N04 8.45e+04
C05 N04 N05 2.71e-08
R05 N04 N05 2.03e+04
C06 N05 N06 3.84e-08
R06 N05 N06 1.09e+03
C07 N06 N07 3.45e-08
R07 N06 N07 1.37e+02
C08 N07 N08 2.19e-08
R08 N07 N08 1.86e+01
C09 N08 N09 1.17e-08
R09 N08 N09 3.30e+00
C10 N09 N10 2.91e-09
R10 N09 N10 1.15e+00
C11 N10 N11 2.20e-09
R11 N10 N11 2.10e-01
C12 N11 N12 4.26e-10
L12 N11 N12 1.67e-11
R12 N11 N12 6.38e-01
C13 N12 N13 5.59e-12
L13 N12 N13 2.47e-10
R13 N12 N13 1.19e+01
C14 N13 Port2 3.77e-12
L14 N13 Port2 1.20e-10
R14 N13 Port2 1.26e+01
.ENDS GCJ219R72A271KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/5.60e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C564KA01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C564KA01 Port1 Port2
C01 Port1 N01 5.49e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.73e-10
R03 N02 N03 9.21e-03
C04 N03 N04 8.55e-05
R04 N03 N04 6.49e+01
C05 N04 N05 6.45e-05
R05 N04 N05 1.26e+01
C06 N05 N06 6.88e-05
R06 N05 N06 1.10e+00
C07 N06 N07 6.76e-05
R07 N06 N07 1.26e-01
C08 N07 N08 3.93e-05
R08 N07 N08 2.30e-02
L09 N08 N09 2.18e-11
R09 N08 N09 6.28e-02
L10 N09 N10 2.13e-10
R10 N09 N10 5.08e-02
C11 N10 N11 2.20e-06
L11 N10 N11 3.87e-11
R11 N10 N11 1.62e-02
C12 N11 N12 9.81e-07
L12 N11 N12 3.61e-11
R12 N11 N12 1.95e-02
C13 N12 N13 1.45e-11
L13 N12 N13 7.42e-11
R13 N12 N13 8.69e+00
C14 N13 Port2 2.61e-12
L14 N13 Port2 1.29e-10
R14 N13 Port2 1.92e+01
.ENDS GCJ21BL81C564KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GRJ216R72A223ME01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ216R72A223ME01 Port1 Port2
C01 Port1 N01 2.17e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.42e-10
R03 N02 N03 1.87e-01
C04 N03 N04 2.66e-06
R04 N03 N04 1.49e+03
C05 N04 N05 7.55e-06
R05 N04 N05 1.19e+02
C06 N05 N06 4.33e-06
R06 N05 N06 4.02e+01
C07 N06 N07 3.63e-06
R07 N06 N07 8.03e+00
C08 N07 N08 2.06e-06
R08 N07 N08 1.49e+00
C09 N08 N09 1.41e-06
R09 N08 N09 2.00e-01
C10 N09 N10 1.60e-06
R10 N09 N10 4.45e-02
L11 N10 N11 9.02e-11
R11 N10 N11 1.44e-01
C12 N11 N12 1.22e-07
L12 N11 N12 1.34e-11
R12 N11 N12 2.67e-02
C13 N12 N13 1.16e-08
L13 N12 N13 4.01e-11
R13 N12 N13 7.33e-02
C14 N13 N14 8.46e-11
L14 N13 N14 8.19e-11
R14 N13 N14 1.03e+00
C15 N14 Port2 2.55e-12
L15 N14 Port2 1.55e-10
R15 N14 Port2 1.70e+01
.ENDS GRJ216R72A223ME01

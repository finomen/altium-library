*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-01[uF]/50[V]
* Murata P/N :GCJ21BR71H184KA01
* Property : C = 1.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H184KA01 Port1 Port2
C01 Port1 N01 1.86e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 1.76e-10
R03 N02 N03 1.96e-02
C04 N03 N04 2.25e-05
R04 N03 N04 1.73e+02
C05 N04 N05 2.97e-05
R05 N04 N05 1.81e+01
C06 N05 N06 3.30e-05
R06 N05 N06 2.55e+00
C07 N06 N07 2.48e-05
R07 N06 N07 5.10e-01
C08 N07 N08 2.06e-05
R08 N07 N08 7.71e-02
C09 N08 N09 1.26e-05
R09 N08 N09 2.03e-02
L10 N09 N10 1.59e-10
R10 N09 N10 6.30e-02
L11 N10 N11 6.14e-12
R11 N10 N11 2.73e-02
C12 N11 N12 1.13e-06
L12 N11 N12 2.20e-11
R12 N11 N12 1.65e-02
C13 N12 N13 3.29e-07
L13 N12 N13 3.26e-11
R13 N12 N13 2.40e-02
C14 N13 N14 1.99e-11
L14 N13 N14 7.73e-11
R14 N13 N14 8.33e+00
C15 N14 Port2 2.03e-12
L15 N14 Port2 1.74e-10
R15 N14 Port2 1.83e+01
.ENDS GCJ21BR71H184KA01

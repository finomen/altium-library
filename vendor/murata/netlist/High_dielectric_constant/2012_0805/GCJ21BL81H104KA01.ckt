*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ21BL81H104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81H104KA01 Port1 Port2
C01 Port1 N01 9.69e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.64e-10
R03 N02 N03 1.88e-02
C04 N03 N04 1.15e-05
R04 N03 N04 1.46e+02
C05 N04 N05 1.28e-05
R05 N04 N05 1.50e+01
C06 N05 N06 1.37e-05
R06 N05 N06 1.97e+00
C07 N06 N07 1.43e-05
R07 N06 N07 3.13e-01
C08 N07 N08 1.06e-05
R08 N07 N08 8.18e-02
C09 N08 N09 8.02e-06
R09 N08 N09 1.80e-02
L10 N09 N10 1.16e-10
R10 N09 N10 1.10e-01
L11 N10 N11 8.83e-12
R11 N10 N11 5.85e-02
C12 N11 N12 3.61e-07
L12 N11 N12 4.08e-11
R12 N11 N12 3.72e-02
C13 N12 N13 9.24e-08
L13 N12 N13 6.82e-11
R13 N12 N13 5.77e-02
C14 N13 N14 1.20e-11
L14 N13 N14 7.42e-11
R14 N13 N14 1.04e+01
C15 N14 Port2 2.47e-12
L15 N14 Port2 1.35e-10
R15 N14 Port2 2.72e+01
.ENDS GCJ21BL81H104KA01

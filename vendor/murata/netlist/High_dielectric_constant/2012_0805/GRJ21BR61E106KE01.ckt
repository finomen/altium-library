*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ21BR61E106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR61E106KE01 Port1 Port2
C01 Port1 N01 6.93e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.86e-10
R03 N02 N03 5.13e-03
C04 N03 N04 1.99e-04
R04 N03 N04 2.66e+01
C05 N04 N05 2.37e-04
R05 N04 N05 2.08e+00
C06 N05 N06 2.37e-04
R06 N05 N06 2.51e-01
C07 N06 N07 1.95e-04
R07 N06 N07 3.43e-02
C08 N07 N08 1.55e-04
R08 N07 N08 4.86e-03
L09 N08 N09 1.53e-11
R09 N08 N09 1.30e-01
L10 N09 N10 4.52e-11
R10 N09 N10 3.31e-02
L11 N10 N11 3.28e-10
R11 N10 N11 1.88e-02
C12 N11 N12 1.82e-05
L12 N11 N12 8.38e-11
R12 N11 N12 4.31e-03
C13 N12 N13 1.12e-05
L13 N12 N13 6.29e-11
R13 N12 N13 4.62e-03
C14 N13 Port2 9.26e-12
L14 N13 Port2 7.39e-11
R14 N13 Port2 1.17e+01
.ENDS GRJ21BR61E106KE01

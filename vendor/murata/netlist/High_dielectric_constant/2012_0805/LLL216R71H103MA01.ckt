*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :LLL216R71H103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71H103MA01 Port1 Port2
C01 Port1 N01 1.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 5.51e-11
R03 N02 N03 2.64e-02
C04 N03 N04 1.31e-06
R04 N03 N04 2.09e+03
C05 N04 N05 2.30e-06
R05 N04 N05 2.52e+02
C06 N05 N06 1.76e-06
R06 N05 N06 6.94e+01
C07 N06 N07 1.49e-06
R07 N06 N07 1.26e+01
C08 N07 N08 1.34e-06
R08 N07 N08 1.82e+00
C09 N08 N09 1.12e-06
R09 N08 N09 2.67e-01
C10 N09 N10 9.13e-07
R10 N09 N10 8.04e-02
C11 N10 N11 5.94e-07
R11 N10 N11 2.36e-02
L12 N11 N12 3.28e-11
R12 N11 N12 1.86e-01
C13 N12 N13 1.56e-08
L13 N12 N13 2.26e-11
R13 N12 N13 1.10e-01
C14 N13 N14 4.85e-09
L14 N13 N14 2.03e-11
R14 N13 N14 9.55e-02
C15 N14 Port2 5.13e-12
L15 N14 Port2 5.23e-11
R15 N14 Port2 9.87e+00
.ENDS LLL216R71H103MA01

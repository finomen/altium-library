*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7S(-55to125[deg])/2.20e+00[uF]/4[V]
* Murata P/N :LLL219C70G225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL219C70G225MA01 Port1 Port2
C01 Port1 N01 1.87e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 6.04e-11
R03 N02 N03 2.56e-03
C04 N03 N04 6.60e-04
R04 N03 N04 3.72e+00
C05 N04 N05 3.16e-04
R05 N04 N05 1.95e+00
C06 N05 N06 2.34e-04
R06 N05 N06 4.11e-01
C07 N06 N07 2.31e-04
R07 N06 N07 5.33e-02
C08 N07 N08 2.63e-04
R08 N07 N08 6.95e-03
C09 N08 N09 1.73e-04
R09 N08 N09 3.03e-03
L10 N09 N10 3.02e-11
R10 N09 N10 1.61e-01
L11 N10 N11 9.05e-11
R11 N10 N11 2.33e-02
C12 N11 N12 3.32e-06
L12 N11 N12 4.44e-11
R12 N11 N12 1.43e-02
C13 N12 N13 1.82e-06
L13 N12 N13 3.04e-11
R13 N12 N13 1.13e-02
C14 N13 N14 9.79e-10
L14 N13 N14 5.22e-12
R14 N13 N14 7.85e-02
C15 N14 Port2 4.92e-12
L15 N14 Port2 4.33e-11
R15 N14 Port2 7.24e+00
.ENDS LLL219C70G225MA01

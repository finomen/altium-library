*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/3.30e+00[uF]/16[V]
* Murata P/N :GRT219R61C335KE01
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT219R61C335KE01 Port1 Port2
C01 Port1 N01 2.46e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 1.95e-10
R03 N02 N03 4.98e-03
C04 N03 N04 8.00e-05
R04 N03 N04 4.21e+01
C05 N04 N05 8.97e-05
R05 N04 N05 5.03e+00
C06 N05 N06 7.97e-05
R06 N05 N06 7.95e-01
C07 N06 N07 7.90e-05
R07 N06 N07 1.31e-01
C08 N07 N08 9.49e-05
R08 N07 N08 2.91e-02
C09 N08 N09 4.60e-05
R09 N08 N09 1.26e-02
L10 N09 N10 1.53e-11
R10 N09 N10 1.02e-01
L11 N10 N11 2.67e-11
R11 N10 N11 2.78e-02
L12 N11 N12 1.95e-10
R12 N11 N12 2.48e-02
C13 N12 N13 8.90e-06
L13 N12 N13 3.43e-11
R13 N12 N13 5.87e-03
C14 N13 N14 3.85e-06
L14 N13 N14 3.89e-11
R14 N13 N14 9.63e-03
C15 N14 Port2 1.21e-11
L15 N14 Port2 6.45e-11
R15 N14 Port2 9.93e+00
.ENDS GRT219R61C335KE01

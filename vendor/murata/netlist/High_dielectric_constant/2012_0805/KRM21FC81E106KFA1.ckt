*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :KRM21FC81E106KFA1
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM21FC81E106KFA1 Port1 Port2
C01 Port1 N01 7.39e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.78e-10
R03 N02 N03 5.04e-03
C04 N03 N04 3.61e-04
R04 N03 N04 3.60e+00
C05 N04 N05 3.29e-04
R05 N04 N05 3.84e-01
C06 N05 N06 2.99e-04
R06 N05 N06 3.46e-02
C07 N06 N07 5.44e-04
R07 N06 N07 3.05e-03
L08 N07 N08 1.56e-10
R08 N07 N08 2.66e+02
L09 N08 N09 6.60e-11
R09 N08 N09 1.05e+01
L10 N09 N10 6.13e-11
R10 N09 N10 7.64e-02
L11 N10 N11 3.69e-10
R11 N10 N11 3.61e-02
L12 N11 N12 4.81e-10
R12 N11 N12 9.95e-03
C13 N12 N13 2.22e-05
L13 N12 N13 5.56e-11
R13 N12 N13 4.38e-03
C14 N13 N14 1.34e-05
L14 N13 N14 4.54e-11
R14 N13 N14 5.73e-03
C15 N14 N15 4.15e-12
L15 N14 N15 1.32e-10
R15 N14 N15 4.81e+01
C16 N15 Port2 7.44e-12
L16 N15 Port2 4.89e-11
R16 N15 Port2 1.29e+01
.ENDS KRM21FC81E106KFA1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-03[uF]/250[V]
* Murata P/N :GRJ21AR72E682KWJ1
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21AR72E682KWJ1 Port1 Port2
C01 Port1 N01 7.03e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.18e-10
R03 N02 N03 1.03e-01
C04 N03 N04 6.65e-07
R04 N03 N04 2.49e+03
C05 N04 N05 7.87e-07
R05 N04 N05 4.53e+02
C06 N05 N06 6.55e-07
R06 N05 N06 9.80e+01
C07 N06 N07 6.11e-07
R07 N06 N07 1.79e+01
C08 N07 N08 4.16e-07
R08 N07 N08 3.92e+00
C09 N08 N09 5.09e-07
R09 N08 N09 4.62e-01
C10 N09 N10 3.29e-07
R10 N09 N10 1.50e-01
L11 N10 N11 5.44e-11
R11 N10 N11 2.24e-01
L12 N11 N12 3.89e-11
R12 N11 N12 1.27e-01
C13 N12 N13 8.70e-08
L13 N12 N13 5.44e-12
R13 N12 N13 2.68e-02
C14 N13 N14 9.85e-09
L14 N13 N14 2.61e-11
R14 N13 N14 1.08e-01
C15 N14 Port2 3.02e-11
L15 N14 Port2 4.99e-11
R15 N14 Port2 1.05e+00
.ENDS GRJ21AR72E682KWJ1

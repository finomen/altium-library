*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GCD216R71H222KA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD216R71H222KA01 Port1 Port2
C01 Port1 N01 2.23e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.13e-11
R03 N02 N03 1.05e-01
C04 N03 N04 2.09e-07
R04 N03 N04 1.15e+04
C05 N04 N05 4.60e-07
R05 N04 N05 6.34e+02
C06 N05 N06 2.81e-07
R06 N05 N06 9.37e+01
C07 N06 N07 2.63e-07
R07 N06 N07 7.61e+00
C08 N07 N08 1.53e-07
R08 N07 N08 1.28e+00
C09 N08 N09 1.50e-07
R09 N08 N09 2.36e-01
C10 N09 N10 1.75e-08
R10 N09 N10 9.52e-02
C11 N10 N11 1.29e-07
R11 N10 N11 6.18e-02
L12 N11 N12 1.71e-10
R12 N11 N12 1.83e+00
C13 N12 N13 2.87e-08
L13 N12 N13 4.24e-12
R13 N12 N13 4.36e-02
C14 N13 N14 9.53e-10
L14 N13 N14 4.10e-11
R14 N13 N14 3.18e-01
C15 N14 N15 4.50e-12
L15 N14 N15 1.25e-10
R15 N14 N15 1.67e+01
C16 N15 Port2 2.97e-12
L16 N15 Port2 9.91e-11
R16 N15 Port2 1.79e+01
.ENDS GCD216R71H222KA01

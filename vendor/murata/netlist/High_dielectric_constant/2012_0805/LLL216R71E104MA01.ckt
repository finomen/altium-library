*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :LLL216R71E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL216R71E104MA01 Port1 Port2
C01 Port1 N01 9.52e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 7.34e-11
R03 N02 N03 6.00e-03
C04 N03 N04 1.12e-05
R04 N03 N04 3.54e+02
C05 N04 N05 1.70e-05
R05 N04 N05 4.25e+01
C06 N05 N06 1.23e-05
R06 N05 N06 7.92e+00
C07 N06 N07 1.49e-05
R07 N06 N07 9.52e-01
C08 N07 N08 1.41e-05
R08 N07 N08 2.04e-01
C09 N08 N09 8.78e-06
R09 N08 N09 5.26e-02
C10 N09 N10 6.06e-06
R10 N09 N10 1.25e-02
C11 N10 N11 2.12e-06
R11 N10 N11 1.32e-03
L12 N11 N12 5.66e-11
R12 N11 N12 6.70e-02
C13 N12 N13 1.42e-07
L13 N12 N13 3.04e-11
R13 N12 N13 4.88e-02
C14 N13 N14 7.77e-08
L14 N13 N14 1.84e-11
R14 N13 N14 3.65e-02
C15 N14 Port2 7.06e-12
L15 N14 Port2 3.95e-11
R15 N14 Port2 8.54e+00
.ENDS LLL216R71E104MA01

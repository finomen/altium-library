*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCD21BR71H223KA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR71H223KA01 Port1 Port2
C01 Port1 N01 2.24e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 2.86e-02
C04 N03 N04 1.33e-06
R04 N03 N04 2.55e+00
C05 N04 N05 2.13e-06
R05 N04 N05 2.86e-01
C06 N05 N06 1.82e-06
R06 N05 N06 7.54e-02
C07 N06 N07 2.00e-06
R07 N06 N07 1.46e-02
L08 N07 N08 7.62e-11
R08 N07 N08 1.36e-01
C09 N08 N09 1.25e-07
L09 N08 N09 1.74e-11
R09 N08 N09 3.92e-02
C10 N09 N10 2.38e-08
L10 N09 N10 3.34e-11
R10 N09 N10 8.25e-02
C11 N10 N11 9.48e-12
L11 N10 N11 1.97e-10
R11 N10 N11 2.20e+01
C12 N11 Port2 3.58e-12
L12 N11 Port2 2.05e-10
R12 N11 Port2 2.14e+01
.ENDS GCD21BR71H223KA01

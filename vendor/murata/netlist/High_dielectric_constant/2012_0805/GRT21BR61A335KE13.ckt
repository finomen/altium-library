*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X5R(-55to85[deg])/3.30e+00[uF]/10[V]
* Murata P/N :GRT21BR61A335KE13
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT21BR61A335KE13 Port1 Port2
C01 Port1 N01 2.42e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 1.27e-10
R03 N02 N03 5.02e-03
C04 N03 N04 6.79e-05
R04 N03 N04 6.52e+01
C05 N04 N05 8.76e-05
R05 N04 N05 6.62e+00
C06 N05 N06 7.42e-05
R06 N05 N06 1.07e+00
C07 N06 N07 6.25e-05
R07 N06 N07 1.73e-01
C08 N07 N08 5.70e-05
R08 N07 N08 2.97e-02
C09 N08 N09 5.48e-05
R09 N08 N09 6.44e-03
L10 N09 N10 2.17e-11
R10 N09 N10 2.50e-01
L11 N10 N11 2.30e-11
R11 N10 N11 3.13e-02
L12 N11 N12 2.17e-10
R12 N11 N12 2.73e-02
C13 N12 N13 6.48e-06
L13 N12 N13 5.35e-11
R13 N12 N13 9.76e-03
C14 N13 N14 4.31e-06
L14 N13 N14 3.85e-11
R14 N13 N14 9.43e-03
C15 N14 N15 1.87e-11
L15 N14 N15 4.39e-11
R15 N14 N15 7.68e+00
C16 N15 Port2 3.57e-12
L16 N15 Port2 7.44e-11
R16 N15 Port2 1.58e+01
.ENDS GRT21BR61A335KE13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ21BR71H474KE01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ21BR71H474KE01 Port1 Port2
C01 Port1 N01 4.55e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.73e-10
R03 N02 N03 9.74e-03
C04 N03 N04 2.83e-05
R04 N03 N04 7.76e-02
C05 N04 N05 4.72e-05
R05 N04 N05 5.52e-03
L06 N05 N06 2.00e-10
R06 N05 N06 5.06e-02
L07 N06 N07 1.26e-11
R07 N06 N07 5.01e-02
C08 N07 N08 1.59e-06
L08 N07 N08 3.89e-11
R08 N07 N08 1.60e-02
C09 N08 N09 7.83e-07
L09 N08 N09 3.74e-11
R09 N08 N09 1.94e-02
C10 N09 N10 1.04e-11
L10 N09 N10 1.13e-10
R10 N09 N10 1.03e+01
C11 N10 Port2 3.70e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 2.26e+01
.ENDS GRJ21BR71H474KE01

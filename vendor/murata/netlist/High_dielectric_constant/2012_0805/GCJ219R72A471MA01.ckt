*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-04[uF]/100[V]
* Murata P/N :GCJ219R72A471MA01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A471MA01 Port1 Port2
C01 Port1 N01 4.87e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 3.50e-01
C04 N03 N04 3.51e-08
R04 N03 N04 3.51e+04
C05 N04 N05 1.01e-07
R05 N04 N05 1.40e+03
C06 N05 N06 8.79e-08
R06 N05 N06 1.84e+02
C07 N06 N07 7.03e-08
R07 N06 N07 3.46e+01
C08 N07 N08 4.15e-08
R08 N07 N08 6.36e+00
C09 N08 N09 1.62e-08
R09 N08 N09 1.30e+00
C10 N09 N10 4.05e-09
R10 N09 N10 4.15e-01
C11 N10 N11 3.03e-09
L11 N10 N11 1.05e-11
R11 N10 N11 1.81e-01
C12 N11 N12 3.72e-10
L12 N11 N12 3.51e-11
R12 N11 N12 5.21e-01
C13 N12 Port2 1.47e-12
L13 N12 Port2 3.66e-10
R13 N12 Port2 1.82e+01
.ENDS GCJ219R72A471MA01

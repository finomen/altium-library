*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/4.70e-01[uF]/10[V]
* Murata P/N :LLL219R71A474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL219R71A474MA01 Port1 Port2
C01 Port1 N01 4.91e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 5.84e-11
R03 N02 N03 3.71e-03
C04 N03 N04 5.43e-05
R04 N03 N04 7.33e+01
C05 N04 N05 8.20e-05
R05 N04 N05 8.81e+00
C06 N05 N06 5.74e-05
R06 N05 N06 1.97e+00
C07 N06 N07 6.40e-05
R07 N06 N07 2.99e-01
C08 N07 N08 5.04e-05
R08 N07 N08 4.16e-02
C09 N08 N09 3.73e-05
R09 N08 N09 6.50e-03
L10 N09 N10 8.70e-11
R10 N09 N10 3.20e-02
L11 N10 N11 5.15e-12
R11 N10 N11 2.15e-02
C12 N11 N12 1.11e-06
L12 N11 N12 2.89e-11
R12 N11 N12 2.79e-02
C13 N12 N13 4.25e-07
L13 N12 N13 2.87e-11
R13 N12 N13 2.30e-02
C14 N13 Port2 5.43e-12
L14 N13 Port2 8.68e-11
R14 N13 Port2 1.10e+01
.ENDS LLL219R71A474MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.50e-02[uF]/250[V]
* Murata P/N :GCJ21BR72E153KXJ3
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR72E153KXJ3 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 3.90e-10
R03 N02 N03 6.87e-02
C04 N03 N04 1.53e-06
R04 N03 N04 1.29e+03
C05 N04 N05 1.82e-06
R05 N04 N05 2.43e+02
C06 N05 N06 1.57e-06
R06 N05 N06 5.38e+01
C07 N06 N07 1.46e-06
R07 N06 N07 1.08e+01
C08 N07 N08 9.48e-07
R08 N07 N08 2.56e+00
C09 N08 N09 1.28e-06
R09 N08 N09 3.49e-01
C10 N09 N10 7.39e-07
R10 N09 N10 8.03e-02
L11 N10 N11 4.88e-11
R11 N10 N11 1.88e-01
L12 N11 N12 4.16e-11
R12 N11 N12 6.50e-02
C13 N12 N13 1.82e-07
L13 N12 N13 5.68e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.52e-08
L14 N13 N14 1.98e-11
R14 N13 N14 5.09e-02
C15 N14 Port2 1.45e-11
L15 N14 Port2 1.25e-10
R15 N14 Port2 6.60e+00
.ENDS GCJ21BR72E153KXJ3

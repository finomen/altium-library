*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ21BR71H473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BR71H473KA01 Port1 Port2
C01 Port1 N01 4.83e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 9.38e-02
C04 N03 N04 7.24e-06
R04 N03 N04 4.09e+02
C05 N04 N05 1.09e-05
R05 N04 N05 4.59e+01
C06 N05 N06 1.42e-05
R06 N05 N06 7.97e+00
C07 N06 N07 8.54e-06
R07 N06 N07 3.17e+00
C08 N07 N08 5.49e-06
R08 N07 N08 5.14e-01
C09 N08 N09 3.39e-06
R09 N08 N09 9.59e-02
L10 N09 N10 1.48e-10
R10 N09 N10 1.72e-01
C11 N10 N11 3.07e-07
L11 N10 N11 1.97e-11
R11 N10 N11 4.20e-02
C12 N11 N12 8.12e-08
L12 N11 N12 2.99e-11
R12 N11 N12 5.19e-02
C13 N12 N13 5.33e-11
L13 N12 N13 1.52e-10
R13 N12 N13 2.37e+00
C14 N13 Port2 2.14e-12
L14 N13 Port2 1.71e-10
R14 N13 Port2 1.62e+01
.ENDS GCJ21BR71H473KA01

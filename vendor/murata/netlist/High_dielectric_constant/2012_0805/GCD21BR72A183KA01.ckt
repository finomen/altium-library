*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCD21BR72A183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR72A183KA01 Port1 Port2
C01 Port1 N01 1.78e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.46e-02
C04 N03 N04 2.43e-06
R04 N03 N04 1.41e+03
C05 N04 N05 3.14e-06
R05 N04 N05 2.14e+02
C06 N05 N06 3.30e-06
R06 N05 N06 3.55e+01
C07 N06 N07 2.71e-06
R07 N06 N07 9.54e+00
C08 N07 N08 1.78e-06
R08 N07 N08 1.76e+00
C09 N08 N09 1.23e-06
R09 N08 N09 2.66e-01
C10 N09 N10 1.06e-06
R10 N09 N10 3.87e-02
L11 N10 N11 3.36e-11
R11 N10 N11 1.03e-01
C12 N11 N12 8.19e-08
L12 N11 N12 1.71e-11
R12 N11 N12 3.98e-02
C13 N12 N13 1.23e-08
L13 N12 N13 3.76e-11
R13 N12 N13 8.94e-02
C14 N13 N14 1.05e-11
L14 N13 N14 1.92e-10
R14 N13 N14 2.13e+01
C15 N14 N15 6.83e-12
L15 N14 N15 1.41e-10
R15 N14 N15 1.30e+01
C16 N15 Port2 3.58e-12
L16 N15 Port2 9.29e-11
R16 N15 Port2 7.49e+00
.ENDS GCD21BR72A183KA01

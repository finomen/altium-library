*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1220M(0508)/X7R(-55to125[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :LLL215R70J474MA11
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL215R70J474MA11 Port1 Port2
C01 Port1 N01 4.38e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 6.58e-11
R03 N02 N03 4.96e-03
C04 N03 N04 5.61e-05
R04 N03 N04 7.10e+01
C05 N04 N05 7.01e-05
R05 N04 N05 9.57e+00
C06 N05 N06 7.19e-05
R06 N05 N06 1.26e+00
C07 N06 N07 6.33e-05
R07 N06 N07 2.24e-01
C08 N07 N08 4.56e-05
R08 N07 N08 4.39e-02
C09 N08 N09 4.45e-05
R09 N08 N09 6.56e-03
C10 N09 N10 5.47e-05
R10 N09 N10 2.07e-03
L11 N10 N11 7.55e-12
R11 N10 N11 4.99e-02
L12 N11 N12 2.78e-11
R12 N11 N12 3.34e-02
C13 N12 N13 7.26e-07
L13 N12 N13 1.76e-11
R13 N12 N13 1.24e-02
C14 N13 N14 1.61e-07
L14 N13 N14 2.16e-11
R14 N13 N14 1.33e-02
C15 N14 Port2 6.48e-12
L15 N14 Port2 5.25e-11
R15 N14 Port2 1.13e+01
.ENDS LLL215R70J474MA11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/6.80e-04[uF]/100[V]
* Murata P/N :GCJ219R72A681MA01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ219R72A681MA01 Port1 Port2
C01 Port1 N01 7.13e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 8.09e-11
R03 N02 N03 2.51e-01
C04 N03 N04 2.92e-08
R04 N03 N04 1.62e+05
C05 N04 N05 1.37e-07
R05 N04 N05 1.95e+03
C06 N05 N06 1.07e-07
R06 N05 N06 2.09e+02
C07 N06 N07 8.54e-08
R07 N06 N07 2.24e+01
C08 N07 N08 5.28e-08
R08 N07 N08 3.29e+00
C09 N08 N09 2.29e-08
R09 N08 N09 6.85e-01
C10 N09 N10 4.29e-09
R10 N09 N10 3.25e-01
C11 N10 N11 2.98e-09
L11 N10 N11 1.72e-11
R11 N10 N11 1.76e-01
C12 N11 N12 4.62e-10
L12 N11 N12 4.05e-11
R12 N11 N12 4.72e-01
C13 N12 N13 7.36e-12
L13 N12 N13 1.26e-10
R13 N12 N13 1.17e+01
C14 N13 Port2 1.06e-12
L14 N13 Port2 2.62e-10
R14 N13 Port2 2.35e+01
.ENDS GCJ219R72A681MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/3.30e-03[uF]/25[V]
* Murata P/N :GCJ216R71E332KA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ216R71E332KA01 Port1 Port2
C01 Port1 N01 3.36e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 1.42e-01
C04 N03 N04 4.72e-07
R04 N03 N04 4.01e+03
C05 N04 N05 6.53e-07
R05 N04 N05 3.11e+02
C06 N05 N06 5.48e-07
R06 N05 N06 4.20e+01
C07 N06 N07 4.15e-07
R07 N06 N07 5.17e+00
C08 N07 N08 2.99e-07
R08 N07 N08 7.04e-01
C09 N08 N09 2.73e-07
R09 N08 N09 1.60e-01
C10 N09 N10 8.58e-08
R10 N09 N10 9.13e-02
C11 N10 N11 2.43e-08
L11 N10 N11 8.62e-12
R11 N10 N11 6.82e-02
C12 N11 N12 1.46e-09
L12 N11 N12 4.29e-11
R12 N11 N12 2.46e-01
C13 N12 N13 4.11e-11
L13 N12 N13 1.08e-10
R13 N12 N13 1.44e+00
C14 N13 N14 8.19e-12
L14 N13 N14 5.65e-11
R14 N13 N14 9.00e+00
C15 N14 Port2 1.88e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 2.83e+01
.ENDS GCJ216R71E332KA01

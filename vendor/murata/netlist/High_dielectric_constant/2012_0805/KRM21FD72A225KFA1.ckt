*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7T(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :KRM21FD72A225KFA1
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM21FD72A225KFA1 Port1 Port2
C01 Port1 N01 2.11e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.27e-10
R03 N02 N03 6.33e-03
C04 N03 N04 2.34e-04
R04 N03 N04 2.51e+01
C05 N04 N05 2.62e-04
R05 N04 N05 2.00e+00
C06 N05 N06 2.14e-04
R06 N05 N06 3.89e-01
C07 N06 N07 2.35e-04
R07 N06 N07 5.25e-02
C08 N07 N08 1.51e-04
R08 N07 N08 1.12e-02
L09 N08 N09 4.36e-11
R09 N08 N09 7.08e-02
L10 N09 N10 4.26e-10
R10 N09 N10 5.75e-02
L11 N10 N11 4.63e-10
R11 N10 N11 4.68e-03
C12 N11 N12 6.71e-06
L12 N11 N12 5.56e-11
R12 N11 N12 1.19e-02
C13 N12 N13 1.60e-06
L13 N12 N13 1.01e-10
R13 N12 N13 1.25e-02
C14 N13 Port2 9.66e-13
L14 N13 Port2 4.68e-10
R14 N13 Port2 3.42e+02
.ENDS KRM21FD72A225KFA1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GCJ21BL8EH474KA07
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL8EH474KA07 Port1 Port2
C01 Port1 N01 4.66e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.79e-10
R03 N02 N03 8.91e-03
C04 N03 N04 6.27e-05
R04 N03 N04 2.65e+01
C05 N04 N05 7.55e-05
R05 N04 N05 3.57e+00
C06 N05 N06 7.09e-05
R06 N05 N06 6.50e-01
C07 N06 N07 6.65e-05
R07 N06 N07 1.24e-01
C08 N07 N08 6.96e-05
R08 N07 N08 2.75e-02
C09 N08 N09 4.51e-05
R09 N08 N09 9.73e-03
L10 N09 N10 1.53e-11
R10 N09 N10 5.75e-02
L11 N10 N11 1.59e-10
R11 N10 N11 4.96e-02
C12 N11 N12 1.80e-06
L12 N11 N12 4.13e-11
R12 N11 N12 1.76e-02
C13 N12 N13 6.63e-07
L13 N12 N13 4.88e-11
R13 N12 N13 2.44e-02
C14 N13 N14 1.82e-11
L14 N13 N14 7.64e-11
R14 N13 N14 9.81e+00
C15 N14 Port2 2.01e-12
L15 N14 Port2 1.54e-10
R15 N14 Port2 2.87e+01
.ENDS GCJ21BL8EH474KA07

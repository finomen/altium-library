*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8L(-55to150[deg])/8.20e-01[uF]/16[V]
* Murata P/N :GCJ21BL81C824KA01
* Property : C = 8.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ21BL81C824KA01 Port1 Port2
C01 Port1 N01 7.85e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 1.62e-10
R03 N02 N03 7.52e-03
C04 N03 N04 9.42e-05
R04 N03 N04 4.22e+01
C05 N04 N05 1.33e-04
R05 N04 N05 3.76e+00
C06 N05 N06 1.06e-04
R06 N05 N06 6.25e-01
C07 N06 N07 9.02e-05
R07 N06 N07 7.86e-02
C08 N07 N08 7.08e-05
R08 N07 N08 1.11e-02
L09 N08 N09 2.04e-11
R09 N08 N09 4.37e-02
L10 N09 N10 2.17e-10
R10 N09 N10 4.25e-02
C11 N10 N11 2.85e-06
L11 N10 N11 4.65e-11
R11 N10 N11 1.26e-02
C12 N11 N12 1.15e-06
L12 N11 N12 4.98e-11
R12 N11 N12 1.47e-02
C13 N12 N13 1.76e-11
L13 N12 N13 6.60e-11
R13 N12 N13 7.47e+00
C14 N13 Port2 2.62e-12
L14 N13 Port2 1.21e-10
R14 N13 Port2 1.76e+01
.ENDS GCJ21BL81C824KA01

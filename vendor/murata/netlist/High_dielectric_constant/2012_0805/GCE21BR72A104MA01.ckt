*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCE21BR72A104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE21BR72A104MA01 Port1 Port2
C01 Port1 N01 9.69e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 6.76e-11
R03 N02 N03 3.16e-02
C04 N03 N04 1.21e-05
R04 N03 N04 3.05e+02
C05 N04 N05 2.03e-05
R05 N04 N05 3.84e+01
C06 N05 N06 1.78e-05
R06 N05 N06 8.59e+00
C07 N06 N07 1.35e-05
R07 N06 N07 2.01e+00
C08 N07 N08 9.91e-06
R08 N07 N08 3.18e-01
C09 N08 N09 5.56e-06
R09 N08 N09 4.78e-02
L10 N09 N10 1.63e-10
R10 N09 N10 1.22e-01
C11 N10 N11 2.87e-07
L11 N10 N11 5.32e-11
R11 N10 N11 7.27e-02
C12 N11 N12 1.24e-07
L12 N11 N12 5.60e-11
R12 N11 N12 7.60e-02
C13 N12 N13 4.79e-11
L13 N12 N13 2.04e-11
R13 N12 N13 3.81e+00
C14 N13 N14 8.73e-12
L14 N13 N14 6.86e-11
R14 N13 N14 8.32e+00
C15 N14 Port2 1.97e-12
L15 N14 Port2 1.69e-10
R15 N14 Port2 2.87e+01
.ENDS GCE21BR72A104MA01

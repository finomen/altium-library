*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X7R(-55to125[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCD21BR72A273KA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD21BR72A273KA01 Port1 Port2
C01 Port1 N01 2.71e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 2.41e-02
C04 N03 N04 3.11e-06
R04 N03 N04 1.31e+03
C05 N04 N05 6.23e-06
R05 N04 N05 1.61e+02
C06 N05 N06 3.36e-06
R06 N05 N06 4.64e+01
C07 N06 N07 2.92e-06
R07 N06 N07 5.45e+00
C08 N07 N08 2.54e-06
R08 N07 N08 7.36e-01
C09 N08 N09 2.23e-06
R09 N08 N09 1.32e-01
C10 N09 N10 1.50e-06
R10 N09 N10 2.78e-02
L11 N10 N11 7.45e-11
R11 N10 N11 9.22e-02
C12 N11 N12 1.38e-07
L12 N11 N12 1.99e-11
R12 N11 N12 4.61e-02
C13 N12 N13 2.83e-08
L13 N12 N13 3.62e-11
R13 N12 N13 8.54e-02
C14 N13 N14 9.15e-12
L14 N13 N14 1.66e-10
R14 N13 N14 2.13e+01
C15 N14 Port2 2.82e-12
L15 N14 Port2 1.95e-10
R15 N14 Port2 1.77e+01
.ENDS GCD21BR72A273KA01

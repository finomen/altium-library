*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-02[uF]/1000[V]
* Murata P/N :GRJ32DR73A153KWJ1
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR73A153KWJ1 Port1 Port2
C01 Port1 N01 1.52e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 3.22e-10
R03 N02 N03 4.86e-02
C04 N03 N04 1.75e-06
R04 N03 N04 1.09e+03
C05 N04 N05 2.06e-06
R05 N04 N05 1.91e+02
C06 N05 N06 1.77e-06
R06 N05 N06 4.21e+01
C07 N06 N07 1.67e-06
R07 N06 N07 8.13e+00
C08 N07 N08 1.38e-06
R08 N07 N08 1.65e+00
C09 N08 N09 9.47e-07
R09 N08 N09 3.56e-01
C10 N09 N10 6.20e-07
R10 N09 N10 5.28e-02
L11 N10 N11 4.86e-11
R11 N10 N11 2.73e-01
L12 N11 N12 8.10e-11
R12 N11 N12 2.00e-01
C13 N12 N13 5.23e-08
L13 N12 N13 3.10e-11
R13 N12 N13 1.03e-01
C14 N13 N14 1.29e-08
L14 N13 N14 4.16e-11
R14 N13 N14 1.21e-01
C15 N14 Port2 9.89e-12
L15 N14 Port2 2.54e-10
R15 N14 Port2 2.17e+01
.ENDS GRJ32DR73A153KWJ1

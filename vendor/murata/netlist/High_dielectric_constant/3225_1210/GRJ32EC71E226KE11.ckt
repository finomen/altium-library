*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRJ32EC71E226KE11
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32EC71E226KE11 Port1 Port2
C01 Port1 N01 2.07e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.61e-10
R03 N02 N03 5.23e-03
C04 N03 N04 2.75e-03
R04 N03 N04 1.85e+00
C05 N04 N05 3.66e-03
R05 N04 N05 1.37e-01
C06 N05 N06 3.22e-03
R06 N05 N06 1.48e-02
C07 N06 N07 1.10e-02
R07 N06 N07 1.20e-02
C08 N07 N08 3.66e-03
R08 N07 N08 1.70e-03
L09 N08 N09 2.48e-11
R09 N08 N09 4.57e-02
L10 N09 N10 5.80e-11
R10 N09 N10 1.34e-02
L11 N10 N11 5.88e-10
R11 N10 N11 1.32e-02
C12 N11 N12 4.88e-05
L12 N11 N12 1.40e-10
R12 N11 N12 5.13e-03
C13 N12 N13 4.79e-05
L13 N12 N13 5.75e-11
R13 N12 N13 3.14e-03
C14 N13 N14 4.19e-11
L14 N13 N14 3.10e-11
R14 N13 N14 2.24e+00
C15 N14 Port2 3.53e-12
L15 N14 Port2 7.81e-11
R15 N14 Port2 1.47e+01
.ENDS GRJ32EC71E226KE11

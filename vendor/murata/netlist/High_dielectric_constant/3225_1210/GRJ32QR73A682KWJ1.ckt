*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-03[uF]/1000[V]
* Murata P/N :GRJ32QR73A682KWJ1
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR73A682KWJ1 Port1 Port2
C01 Port1 N01 6.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.41e-10
R03 N02 N03 8.59e-02
C04 N03 N04 6.63e-07
R04 N03 N04 2.48e+03
C05 N04 N05 8.09e-07
R05 N04 N05 3.90e+02
C06 N05 N06 6.96e-07
R06 N05 N06 8.18e+01
C07 N06 N07 6.81e-07
R07 N06 N07 1.41e+01
C08 N07 N08 4.98e-07
R08 N07 N08 2.84e+00
C09 N08 N09 4.47e-07
R09 N08 N09 4.68e-01
C10 N09 N10 2.47e-07
R10 N09 N10 1.00e-01
L11 N10 N11 4.40e-11
R11 N10 N11 4.02e-01
L12 N11 N12 3.59e-11
R12 N11 N12 1.89e-01
C13 N12 N13 4.00e-08
L13 N12 N13 8.54e-12
R13 N12 N13 5.68e-02
C14 N13 N14 8.39e-09
L14 N13 N14 1.24e-11
R14 N13 N14 9.81e-02
C15 N14 Port2 9.29e-12
L15 N14 Port2 2.61e-10
R15 N14 Port2 2.31e+01
.ENDS GRJ32QR73A682KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8R(-55to150[deg])/6.80e+00[uF]/16[V]
* Murata P/N :GCJ32ER91C685KE01
* Property : C = 6.80e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER91C685KE01 Port1 Port2
C01 Port1 N01 6.62e-06
R01 Port1 N01 7.35e+06
L02 N01 N02 1.02e-10
R03 N02 N03 4.41e-03
C04 N03 N04 3.52e-04
R04 N03 N04 1.51e+01
C05 N04 N05 4.09e-04
R05 N04 N05 2.36e+00
C06 N05 N06 2.78e-04
R06 N05 N06 4.32e-01
C07 N06 N07 2.43e-04
R07 N06 N07 5.83e-02
C08 N07 N08 1.82e-04
R08 N07 N08 7.64e-03
C09 N08 N09 1.23e-03
R09 N08 N09 1.92e-04
L10 N09 N10 1.08e-11
R10 N09 N10 3.93e-02
L11 N10 N11 5.07e-11
R11 N10 N11 2.32e-02
L12 N11 N12 3.77e-10
R12 N11 N12 1.94e-02
C13 N12 N13 1.51e-05
L13 N12 N13 1.05e-10
R13 N12 N13 1.22e-02
C14 N13 N14 8.04e-06
L14 N13 N14 8.09e-11
R14 N13 N14 9.45e-03
C15 N14 N15 1.58e-11
L15 N14 N15 8.79e-11
R15 N14 N15 1.90e+01
C16 N15 Port2 2.26e-12
L16 N15 Port2 2.08e-10
R16 N15 Port2 1.02e+02
.ENDS GCJ32ER91C685KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-03[uF]/630[V]
* Murata P/N :GCJ32QR72J682KXJ1
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72J682KXJ1 Port1 Port2
C01 Port1 N01 7.03e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-10
R03 N02 N03 8.59e-02
C04 N03 N04 6.36e-07
R04 N03 N04 2.63e+03
C05 N04 N05 7.95e-07
R05 N04 N05 3.99e+02
C06 N05 N06 7.00e-07
R06 N05 N06 8.14e+01
C07 N06 N07 6.82e-07
R07 N06 N07 1.40e+01
C08 N07 N08 4.76e-07
R08 N07 N08 2.88e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.59e-01
C10 N09 N10 2.45e-07
R10 N09 N10 9.80e-02
L11 N10 N11 4.67e-11
R11 N10 N11 4.56e-01
L12 N11 N12 3.56e-11
R12 N11 N12 1.86e-01
C13 N12 N13 4.06e-08
L13 N12 N13 8.40e-12
R13 N12 N13 5.66e-02
C14 N13 N14 8.51e-09
L14 N13 N14 1.22e-11
R14 N13 N14 9.79e-02
C15 N14 Port2 9.05e-12
L15 N14 Port2 2.65e-10
R15 N14 Port2 2.40e+01
.ENDS GCJ32QR72J682KXJ1

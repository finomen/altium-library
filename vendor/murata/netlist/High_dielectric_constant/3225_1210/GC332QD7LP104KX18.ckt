*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/1.00e-01[uF]/450[V]
* Murata P/N :GC332QD7LP104KX18
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC332QD7LP104KX18 Port1 Port2
C01 Port1 N01 1.02e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 3.14e-10
R03 N02 N03 8.98e-03
C04 N03 N04 3.64e-05
R04 N03 N04 6.46e+01
C05 N04 N05 4.96e-05
R05 N04 N05 9.21e+00
C06 N05 N06 4.57e-05
R06 N05 N06 2.02e+00
C07 N06 N07 4.19e-05
R07 N06 N07 4.41e-01
C08 N07 N08 2.08e-05
R08 N07 N08 1.20e-01
C09 N08 N09 3.12e-05
R09 N08 N09 1.54e-02
L10 N09 N10 8.90e-11
R10 N09 N10 5.30e-02
L11 N10 N11 3.19e-11
R11 N10 N11 5.19e-02
C12 N11 N12 2.34e-07
L12 N11 N12 5.53e-11
R12 N11 N12 7.70e-02
C13 N12 N13 1.15e-07
L13 N12 N13 3.94e-11
R13 N12 N13 6.81e-02
C14 N13 Port2 1.04e-11
L14 N13 Port2 1.82e-10
R14 N13 Port2 1.52e+01
.ENDS GC332QD7LP104KX18

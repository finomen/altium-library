*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRJ32ER70J476KE11
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER70J476KE11 Port1 Port2
C01 Port1 N01 3.44e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 7.49e-11
R03 N02 N03 3.07e-03
C04 N03 N04 8.65e-04
R04 N03 N04 6.13e+00
C05 N04 N05 1.13e-03
R05 N04 N05 3.92e-01
C06 N05 N06 1.22e-03
R06 N05 N06 4.75e-02
C07 N06 N07 8.85e-04
R07 N06 N07 1.03e-02
C08 N07 N08 6.40e-04
R08 N07 N08 9.74e-04
L09 N08 N09 1.17e-11
R09 N08 N09 2.72e-02
L10 N09 N10 8.77e-11
R10 N09 N10 2.68e-02
L11 N10 N11 5.85e-10
R11 N10 N11 1.09e-02
C12 N11 N12 7.35e-05
L12 N11 N12 1.58e-10
R12 N11 N12 3.61e-03
C13 N12 N13 6.25e-05
L13 N12 N13 8.23e-11
R13 N12 N13 3.41e-03
C14 N13 N14 3.95e-11
L14 N13 N14 6.92e-11
R14 N13 N14 4.45e+00
C15 N14 Port2 1.92e-12
L15 N14 Port2 2.89e-10
R15 N14 Port2 6.06e+01
.ENDS GRJ32ER70J476KE11

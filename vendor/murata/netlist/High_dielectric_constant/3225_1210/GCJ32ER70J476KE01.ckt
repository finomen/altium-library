*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GCJ32ER70J476KE01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER70J476KE01 Port1 Port2
C01 Port1 N01 3.22e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.01e-10
R03 N02 N03 3.72e-03
C04 N03 N04 9.31e-04
R04 N03 N04 5.20e+00
C05 N04 N05 1.22e-03
R05 N04 N05 5.31e-01
C06 N05 N06 1.06e-03
R06 N05 N06 8.12e-02
C07 N06 N07 1.10e-03
R07 N06 N07 1.06e-02
C08 N07 N08 8.50e-04
R08 N07 N08 1.96e-03
L09 N08 N09 2.44e-11
R09 N08 N09 3.58e-02
L10 N09 N10 7.19e-11
R10 N09 N10 1.91e-02
L11 N10 N11 4.53e-10
R11 N10 N11 9.88e-03
C12 N11 N12 8.32e-05
L12 N11 N12 1.32e-10
R12 N11 N12 3.55e-03
C13 N12 N13 4.78e-05
L13 N12 N13 9.94e-11
R13 N12 N13 3.55e-03
C14 N13 N14 5.27e-11
L14 N13 N14 6.94e-11
R14 N13 N14 5.22e+00
C15 N14 N15 1.21e-11
L15 N14 N15 1.02e-10
R15 N14 N15 1.68e+01
C16 N15 Port2 3.97e-12
L16 N15 Port2 1.84e-10
R16 N15 Port2 4.84e+01
.ENDS GCJ32ER70J476KE01

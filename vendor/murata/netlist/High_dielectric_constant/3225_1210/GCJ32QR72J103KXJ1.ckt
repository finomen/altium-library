*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GCJ32QR72J103KXJ1
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72J103KXJ1 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.77e-10
R03 N02 N03 7.19e-02
C04 N03 N04 1.12e-06
R04 N03 N04 1.63e+03
C05 N04 N05 1.35e-06
R05 N04 N05 2.70e+02
C06 N05 N06 1.17e-06
R06 N05 N06 5.78e+01
C07 N06 N07 1.11e-06
R07 N06 N07 1.11e+01
C08 N07 N08 8.38e-07
R08 N07 N08 2.29e+00
C09 N08 N09 6.55e-07
R09 N08 N09 3.47e-01
C10 N09 N10 4.12e-07
R10 N09 N10 1.10e-01
L11 N10 N11 3.09e-11
R11 N10 N11 2.88e-01
L12 N11 N12 7.14e-11
R12 N11 N12 2.26e-01
C13 N12 N13 3.75e-08
L13 N12 N13 1.94e-11
R13 N12 N13 7.87e-02
C14 N13 N14 9.09e-09
L14 N13 N14 2.42e-11
R14 N13 N14 1.01e-01
C15 N14 Port2 1.23e-11
L15 N14 Port2 1.49e-10
R15 N14 Port2 9.41e+00
.ENDS GCJ32QR72J103KXJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GCJ32DR72E224KXJ1
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72E224KXJ1 Port1 Port2
C01 Port1 N01 2.28e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.64e-10
R03 N02 N03 1.25e-02
C04 N03 N04 2.17e-05
R04 N03 N04 5.47e+01
C05 N04 N05 2.40e-05
R05 N04 N05 1.25e+01
C06 N05 N06 1.78e-05
R06 N05 N06 3.47e+00
C07 N06 N07 1.76e-05
R07 N06 N07 5.66e-01
C08 N07 N08 1.67e-05
R08 N07 N08 8.53e-02
C09 N08 N09 2.14e-05
R09 N08 N09 1.17e-02
L10 N09 N10 3.48e-11
R10 N09 N10 1.58e-01
L11 N10 N11 1.48e-10
R11 N10 N11 6.82e-02
C12 N11 N12 5.68e-07
L12 N11 N12 6.58e-11
R12 N11 N12 5.02e-02
C13 N12 N13 2.89e-07
L13 N12 N13 4.75e-11
R13 N12 N13 4.45e-02
C14 N13 Port2 2.31e-11
L14 N13 Port2 7.57e-11
R14 N13 Port2 4.37e+00
.ENDS GCJ32DR72E224KXJ1

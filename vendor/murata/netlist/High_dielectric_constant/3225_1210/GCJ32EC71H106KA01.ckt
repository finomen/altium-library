*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GCJ32EC71H106KA01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EC71H106KA01 Port1 Port2
C01 Port1 N01 9.69e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.05e-10
R03 N02 N03 2.86e-03
C04 N03 N04 1.55e-03
R04 N03 N04 1.80e+00
C05 N04 N05 1.75e-03
R05 N04 N05 1.72e-01
C06 N05 N06 1.59e-03
R06 N05 N06 2.90e-02
C07 N06 N07 1.28e-03
R07 N06 N07 3.10e-03
L08 N07 N08 1.73e-11
R08 N07 N08 7.16e-02
L09 N08 N09 4.21e-11
R09 N08 N09 1.92e-02
L10 N09 N10 4.31e-10
R10 N09 N10 1.76e-02
C11 N10 N11 1.73e-05
L11 N10 N11 1.74e-10
R11 N10 N11 1.21e-02
C12 N11 N12 1.63e-05
L12 N11 N12 7.59e-11
R12 N11 N12 8.58e-03
C13 N12 N13 4.78e-11
L13 N12 N13 3.33e-11
R13 N12 N13 4.99e+00
C14 N13 Port2 2.37e-12
L14 N13 Port2 1.98e-10
R14 N13 Port2 1.07e+02
.ENDS GCJ32EC71H106KA01

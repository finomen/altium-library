*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A226ME11
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A226ME11 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 7.15e-11
R03 N02 N03 5.15e-03
C04 N03 N04 4.79e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.94e-04
R05 N04 N05 1.16e+00
C06 N05 N06 4.48e-04
R06 N05 N06 1.20e-01
C07 N06 N07 5.23e-04
R07 N06 N07 9.95e-03
C08 N07 N08 4.39e-04
R08 N07 N08 4.55e-03
L09 N08 N09 6.43e-11
R09 N08 N09 4.02e-02
L10 N09 N10 5.67e-10
R10 N09 N10 1.40e-02
C11 N10 N11 5.83e-05
L11 N10 N11 8.44e-11
R11 N10 N11 5.31e-03
C12 N11 N12 3.65e-05
L12 N11 N12 6.07e-11
R12 N11 N12 3.69e-03
C13 N12 N13 5.16e-11
L13 N12 N13 5.20e-11
R13 N12 N13 2.82e+00
C14 N13 N14 1.50e-11
L14 N13 N14 6.76e-11
R14 N13 N14 3.94e+00
C15 N14 Port2 2.41e-12
L15 N14 Port2 1.79e-10
R15 N14 Port2 1.11e+02
.ENDS GRJ32ER71A226ME11

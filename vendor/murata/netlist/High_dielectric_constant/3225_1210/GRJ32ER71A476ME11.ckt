*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRJ32ER71A476ME11
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71A476ME11 Port1 Port2
C01 Port1 N01 3.21e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.38e-10
R03 N02 N03 4.25e-03
C04 N03 N04 8.73e-04
R04 N03 N04 3.11e+00
C05 N04 N05 1.11e-03
R05 N04 N05 2.38e-01
C06 N05 N06 1.05e-03
R06 N05 N06 3.36e-02
C07 N06 N07 7.61e-04
R07 N06 N07 4.56e-03
L08 N07 N08 2.49e-11
R08 N07 N08 3.38e-02
L09 N08 N09 6.89e-11
R09 N08 N09 1.88e-02
L10 N09 N10 4.08e-10
R10 N09 N10 9.76e-03
C11 N10 N11 6.83e-05
L11 N10 N11 1.39e-10
R11 N10 N11 3.78e-03
C12 N11 N12 4.86e-05
L12 N11 N12 9.84e-11
R12 N11 N12 3.98e-03
C13 N12 N13 4.43e-11
L13 N12 N13 8.12e-11
R13 N12 N13 7.23e+00
C14 N13 N14 1.03e-11
L14 N13 N14 1.13e-10
R14 N13 N14 2.33e+01
C15 N14 Port2 7.47e-12
L15 N14 Port2 1.01e-10
R15 N14 Port2 4.03e+01
.ENDS GRJ32ER71A476ME11

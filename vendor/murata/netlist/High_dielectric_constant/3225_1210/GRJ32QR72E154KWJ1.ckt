*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-01[uF]/250[V]
* Murata P/N :GRJ32QR72E154KWJ1
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR72E154KWJ1 Port1 Port2
C01 Port1 N01 1.58e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 3.50e-10
R03 N02 N03 1.74e-02
C04 N03 N04 1.10e-05
R04 N03 N04 1.08e+02
C05 N04 N05 1.47e-05
R05 N04 N05 1.81e+01
C06 N05 N06 1.14e-05
R06 N05 N06 4.06e+00
C07 N06 N07 1.03e-05
R07 N06 N07 7.64e-01
C08 N07 N08 1.04e-05
R08 N07 N08 1.08e-01
C09 N08 N09 9.17e-06
R09 N08 N09 1.57e-02
L10 N09 N10 4.81e-11
R10 N09 N10 9.03e-02
L11 N10 N11 1.20e-10
R11 N10 N11 5.47e-02
C12 N11 N12 6.89e-07
L12 N11 N12 2.74e-11
R12 N11 N12 2.68e-02
C13 N12 N13 1.20e-07
L13 N12 N13 5.58e-11
R13 N12 N13 3.67e-02
C14 N13 Port2 2.12e-11
L14 N13 Port2 5.44e-11
R14 N13 Port2 1.54e+00
.ENDS GRJ32QR72E154KWJ1

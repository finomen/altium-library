*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :GR332DD72J333KW01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR332DD72J333KW01 Port1 Port2
C01 Port1 N01 3.36e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 3.38e-10
R03 N02 N03 1.54e-02
C04 N03 N04 1.21e-05
R04 N03 N04 1.83e+02
C05 N04 N05 1.72e-05
R05 N04 N05 2.23e+01
C06 N05 N06 1.64e-05
R06 N05 N06 4.71e+00
C07 N06 N07 1.46e-05
R07 N06 N07 9.75e-01
C08 N07 N08 8.27e-06
R08 N07 N08 2.34e-01
C09 N08 N09 8.08e-06
R09 N08 N09 3.64e-02
L10 N09 N10 8.29e-11
R10 N09 N10 9.61e-02
L11 N10 N11 4.67e-11
R11 N10 N11 4.11e-02
C12 N11 N12 9.92e-08
L12 N11 N12 4.55e-11
R12 N11 N12 1.34e-01
C13 N12 N13 3.71e-08
L13 N12 N13 4.30e-11
R13 N12 N13 1.09e-01
C14 N13 N14 5.17e-10
L14 N13 N14 1.25e-11
R14 N13 N14 2.01e-01
C15 N14 Port2 1.07e-11
L15 N14 Port2 2.07e-10
R15 N14 Port2 2.39e+01
.ENDS GR332DD72J333KW01

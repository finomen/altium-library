*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/6.80e-02[uF]/630[V]
* Murata P/N :GR332DD7LQ683KW01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR332DD7LQ683KW01 Port1 Port2
C01 Port1 N01 6.82e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 3.54e-10
R03 N02 N03 1.06e-02
C04 N03 N04 2.42e-05
R04 N03 N04 9.05e+01
C05 N04 N05 3.30e-05
R05 N04 N05 1.25e+01
C06 N05 N06 3.04e-05
R06 N05 N06 2.60e+00
C07 N06 N07 2.84e-05
R07 N06 N07 5.04e-01
C08 N07 N08 2.39e-05
R08 N07 N08 1.03e-01
C09 N08 N09 1.89e-05
R09 N08 N09 1.57e-02
L10 N09 N10 7.24e-11
R10 N09 N10 7.77e-02
L11 N10 N11 2.61e-11
R11 N10 N11 3.87e-02
C12 N11 N12 1.91e-07
L12 N11 N12 4.93e-11
R12 N11 N12 9.37e-02
C13 N12 N13 5.42e-08
L13 N12 N13 6.18e-11
R13 N12 N13 8.42e-02
C14 N13 N14 4.79e-10
L14 N13 N14 1.28e-11
R14 N13 N14 2.34e-01
C15 N14 Port2 1.00e-11
L15 N14 Port2 2.35e-10
R15 N14 Port2 3.14e+01
.ENDS GR332DD7LQ683KW01

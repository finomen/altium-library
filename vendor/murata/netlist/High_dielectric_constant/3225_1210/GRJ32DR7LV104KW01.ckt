*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GRJ32DR7LV104KW01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR7LV104KW01 Port1 Port2
C01 Port1 N01 1.04e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 3.48e-10
R03 N02 N03 2.10e-02
C04 N03 N04 9.82e-06
R04 N03 N04 1.86e+02
C05 N04 N05 1.16e-05
R05 N04 N05 3.52e+01
C06 N05 N06 9.56e-06
R06 N05 N06 7.90e+00
C07 N06 N07 8.71e-06
R07 N06 N07 1.48e+00
C08 N07 N08 7.96e-06
R08 N07 N08 3.07e-01
C09 N08 N09 7.58e-06
R09 N08 N09 3.92e-02
L10 N09 N10 2.78e-11
R10 N09 N10 8.80e-02
L11 N10 N11 1.27e-10
R11 N10 N11 6.20e-02
C12 N11 N12 4.52e-07
L12 N11 N12 3.30e-11
R12 N11 N12 3.86e-02
C13 N12 N13 8.80e-08
L13 N12 N13 5.49e-11
R13 N12 N13 4.06e-02
C14 N13 Port2 1.04e-11
L14 N13 Port2 2.09e-10
R14 N13 Port2 1.68e+01
.ENDS GRJ32DR7LV104KW01

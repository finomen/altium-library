*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/1.50e-01[uF]/450[V]
* Murata P/N :GC332DD7LP154KX18
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC332DD7LP154KX18 Port1 Port2
C01 Port1 N01 1.51e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 3.68e-10
R03 N02 N03 6.95e-03
C04 N03 N04 5.50e-05
R04 N03 N04 4.54e+01
C05 N04 N05 7.35e-05
R05 N04 N05 6.90e+00
C06 N05 N06 6.74e-05
R06 N05 N06 1.50e+00
C07 N06 N07 6.06e-05
R07 N06 N07 3.28e-01
C08 N07 N08 4.36e-05
R08 N07 N08 7.05e-02
C09 N08 N09 4.33e-05
R09 N08 N09 1.69e-02
L10 N09 N10 1.15e-11
R10 N09 N10 8.51e-02
L11 N10 N11 1.40e-10
R11 N10 N11 7.89e-02
C12 N11 N12 4.26e-07
L12 N11 N12 5.88e-11
R12 N11 N12 9.02e-02
C13 N12 N13 1.86e-07
L13 N12 N13 5.23e-11
R13 N12 N13 7.26e-02
C14 N13 Port2 1.51e-11
L14 N13 Port2 1.29e-10
R14 N13 Port2 9.05e+00
.ENDS GC332DD7LP154KX18

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GRJ32DR72J473KWJ1
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72J473KWJ1 Port1 Port2
C01 Port1 N01 4.75e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 3.25e-10
R03 N02 N03 2.45e-02
C04 N03 N04 5.95e-06
R04 N03 N04 3.10e+02
C05 N04 N05 5.01e-06
R05 N04 N05 1.32e+02
C06 N05 N06 4.60e-06
R06 N05 N06 2.67e+01
C07 N06 N07 4.54e-06
R07 N06 N07 5.95e+00
C08 N07 N08 3.99e-06
R08 N07 N08 1.29e+00
C09 N08 N09 3.49e-06
R09 N08 N09 3.13e-01
C10 N09 N10 2.29e-06
R10 N09 N10 6.08e-02
L11 N10 N11 9.77e-11
R11 N10 N11 1.23e-01
L12 N11 N12 3.23e-11
R12 N11 N12 7.36e-02
C13 N12 N13 1.32e-07
L13 N12 N13 5.98e-11
R13 N12 N13 1.14e-01
C14 N13 N14 3.35e-08
L14 N13 N14 8.57e-11
R14 N13 N14 1.09e-01
C15 N14 Port2 2.62e-11
L15 N14 Port2 7.16e-11
R15 N14 Port2 3.13e+00
.ENDS GRJ32DR72J473KWJ1

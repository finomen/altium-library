*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ32ER71H475KA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32ER71H475KA12 Port1 Port2
C01 Port1 N01 4.70e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.01e-10
R03 N02 N03 3.78e-03
C04 N03 N04 8.05e-04
R04 N03 N04 1.63e+00
C05 N04 N05 6.27e-04
R05 N04 N05 3.35e-01
C06 N05 N06 5.80e-04
R06 N05 N06 5.97e-02
C07 N06 N07 7.46e-04
R07 N06 N07 8.28e-03
C08 N07 N08 5.27e-04
R08 N07 N08 2.71e-03
L09 N08 N09 1.71e-11
R09 N08 N09 6.72e-02
L10 N09 N10 3.87e-10
R10 N09 N10 2.53e-02
L11 N10 N11 3.84e-11
R11 N10 N11 2.45e-02
C12 N11 N12 9.02e-06
L12 N11 N12 1.36e-10
R12 N11 N12 1.48e-02
C13 N12 N13 8.17e-06
L13 N12 N13 6.10e-11
R13 N12 N13 1.02e-02
C14 N13 N14 2.50e-11
L14 N13 N14 6.57e-11
R14 N13 N14 5.59e+00
C15 N14 Port2 2.60e-12
L15 N14 Port2 1.81e-10
R15 N14 Port2 1.18e+02
.ENDS GCJ32ER71H475KA12

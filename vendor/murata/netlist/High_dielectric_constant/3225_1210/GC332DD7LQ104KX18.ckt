*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GC332DD7LQ104KX18
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC332DD7LQ104KX18 Port1 Port2
C01 Port1 N01 1.01e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 3.57e-10
R03 N02 N03 8.05e-03
C04 N03 N04 3.37e-05
R04 N03 N04 7.26e+01
C05 N04 N05 4.75e-05
R05 N04 N05 1.03e+01
C06 N05 N06 4.38e-05
R06 N05 N06 2.18e+00
C07 N06 N07 4.19e-05
R07 N06 N07 4.31e-01
C08 N07 N08 3.66e-05
R08 N07 N08 9.27e-02
C09 N08 N09 2.63e-05
R09 N08 N09 1.64e-02
L10 N09 N10 1.58e-10
R10 N09 N10 1.09e-01
L11 N10 N11 1.22e-11
R11 N10 N11 8.58e-02
C12 N11 N12 1.58e-07
L12 N11 N12 1.08e-10
R12 N11 N12 1.36e-01
C13 N12 N13 1.42e-07
L13 N12 N13 4.80e-11
R13 N12 N13 1.02e-01
C14 N13 Port2 3.51e-11
L14 N13 Port2 5.76e-11
R14 N13 Port2 2.82e+00
.ENDS GC332DD7LQ104KX18

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GC332DD72J473KX01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC332DD72J473KX01 Port1 Port2
C01 Port1 N01 4.66e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 3.48e-10
R03 N02 N03 1.19e-02
C04 N03 N04 1.90e-05
R04 N03 N04 1.13e+02
C05 N04 N05 2.48e-05
R05 N04 N05 1.54e+01
C06 N05 N06 2.30e-05
R06 N05 N06 3.18e+00
C07 N06 N07 2.05e-05
R07 N06 N07 6.44e-01
C08 N07 N08 1.64e-05
R08 N07 N08 1.26e-01
C09 N08 N09 1.35e-05
R09 N08 N09 1.80e-02
L10 N09 N10 1.18e-10
R10 N09 N10 1.22e-01
L11 N10 N11 3.52e-11
R11 N10 N11 7.63e-02
C12 N11 N12 8.72e-08
L12 N11 N12 8.87e-11
R12 N11 N12 2.05e-01
C13 N12 N13 5.38e-08
L13 N12 N13 5.50e-11
R13 N12 N13 1.32e-01
C14 N13 Port2 2.53e-11
L14 N13 Port2 6.46e-11
R14 N13 Port2 3.21e+00
.ENDS GC332DD72J473KX01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GRJ32QR72J223KWJ1
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32QR72J223KWJ1 Port1 Port2
C01 Port1 N01 2.27e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 3.44e-10
R03 N02 N03 4.08e-02
C04 N03 N04 2.43e-06
R04 N03 N04 8.01e+02
C05 N04 N05 2.77e-06
R05 N04 N05 1.62e+02
C06 N05 N06 2.36e-06
R06 N05 N06 3.67e+01
C07 N06 N07 2.27e-06
R07 N06 N07 7.47e+00
C08 N07 N08 1.90e-06
R08 N07 N08 1.55e+00
C09 N08 N09 1.49e-06
R09 N08 N09 3.61e-01
C10 N09 N10 1.12e-06
R10 N09 N10 6.42e-02
L11 N10 N11 3.84e-11
R11 N10 N11 2.22e-01
L12 N11 N12 7.23e-11
R12 N11 N12 1.95e-01
C13 N12 N13 7.89e-08
L13 N12 N13 2.44e-11
R13 N12 N13 7.76e-02
C14 N13 N14 1.53e-08
L14 N13 N14 4.20e-11
R14 N13 N14 1.06e-01
C15 N14 Port2 1.49e-11
L15 N14 Port2 1.14e-10
R15 N14 Port2 7.22e+00
.ENDS GRJ32QR72J223KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ32DC72A475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DC72A475ME11 Port1 Port2
C01 Port1 N01 4.51e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.37e-11
R03 N02 N03 3.45e-03
C04 N03 N04 5.12e-04
R04 N03 N04 4.87e+00
C05 N04 N05 4.73e-04
R05 N04 N05 5.59e-01
C06 N05 N06 3.88e-04
R06 N05 N06 1.07e-01
C07 N06 N07 3.31e-04
R07 N06 N07 1.06e-02
C08 N07 N08 2.79e-04
R08 N07 N08 7.95e-04
L09 N08 N09 1.03e-11
R09 N08 N09 4.42e-02
L10 N09 N10 4.47e-11
R10 N09 N10 3.61e-02
L11 N10 N11 3.77e-10
R11 N10 N11 2.44e-02
C12 N11 N12 1.02e-05
L12 N11 N12 1.06e-10
R12 N11 N12 1.27e-02
C13 N12 N13 6.47e-06
L13 N12 N13 6.72e-11
R13 N12 N13 9.93e-03
C14 N13 N14 3.24e-11
L14 N13 N14 5.15e-11
R14 N13 N14 4.06e+00
C15 N14 Port2 1.49e-12
L15 N14 Port2 2.65e-10
R15 N14 Port2 1.19e+02
.ENDS GRJ32DC72A475ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GCJ32DC72A475KE01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DC72A475KE01 Port1 Port2
C01 Port1 N01 4.58e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.03e-10
R03 N02 N03 3.51e-03
C04 N03 N04 6.25e-04
R04 N03 N04 4.80e+00
C05 N04 N05 4.90e-04
R05 N04 N05 8.22e-01
C06 N05 N06 4.28e-04
R06 N05 N06 1.37e-01
C07 N06 N07 4.74e-04
R07 N06 N07 1.63e-02
C08 N07 N08 4.24e-04
R08 N07 N08 2.75e-03
L09 N08 N09 1.15e-11
R09 N08 N09 4.00e-02
L10 N09 N10 4.06e-11
R10 N09 N10 2.92e-02
L11 N10 N11 3.12e-10
R11 N10 N11 2.33e-02
C12 N11 N12 8.90e-06
L12 N11 N12 1.21e-10
R12 N11 N12 1.34e-02
C13 N12 N13 5.99e-06
L13 N12 N13 7.23e-11
R13 N12 N13 1.07e-02
C14 N13 N14 2.37e-11
L14 N13 N14 6.94e-11
R14 N13 N14 5.72e+00
C15 N14 Port2 2.34e-12
L15 N14 Port2 1.78e-10
R15 N14 Port2 1.73e+02
.ENDS GCJ32DC72A475KE01

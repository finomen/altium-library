*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GCJ32EC71E226KE02
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EC71E226KE02 Port1 Port2
C01 Port1 N01 2.06e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.53e-10
R03 N02 N03 2.24e-03
C04 N03 N04 2.42e-03
R04 N03 N04 2.76e+00
C05 N04 N05 3.67e-03
R05 N04 N05 1.79e-01
C06 N05 N06 2.81e-03
R06 N05 N06 2.85e-02
C07 N06 N07 4.82e-03
R07 N06 N07 2.02e-03
C08 N07 N08 2.25e-03
R08 N07 N08 3.98e-04
L09 N08 N09 1.87e-11
R09 N08 N09 5.20e-02
L10 N09 N10 7.42e-11
R10 N09 N10 2.15e-02
L11 N10 N11 6.03e-10
R11 N10 N11 1.49e-02
C12 N11 N12 4.72e-05
L12 N11 N12 1.58e-10
R12 N11 N12 5.59e-03
C13 N12 N13 5.19e-05
L13 N12 N13 5.79e-11
R13 N12 N13 3.32e-03
C14 N13 N14 4.88e-11
L14 N13 N14 3.23e-11
R14 N13 N14 2.13e+00
C15 N14 Port2 2.69e-12
L15 N14 Port2 8.94e-11
R15 N14 Port2 1.00e+01
.ENDS GCJ32EC71E226KE02

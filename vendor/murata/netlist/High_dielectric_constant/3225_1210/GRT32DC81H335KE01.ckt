*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/3.30e+00[uF]/50[V]
* Murata P/N :GRT32DC81H335KE01
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DC81H335KE01 Port1 Port2
C01 Port1 N01 3.28e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 4.28e-11
R03 N02 N03 2.34e-03
C04 N03 N04 3.14e-04
R04 N03 N04 4.45e+00
C05 N04 N05 4.91e-04
R05 N04 N05 3.96e-01
C06 N05 N06 3.79e-04
R06 N05 N06 7.02e-02
C07 N06 N07 3.58e-04
R07 N06 N07 9.66e-03
C08 N07 N08 3.45e-04
R08 N07 N08 1.71e-03
L09 N08 N09 2.67e-11
R09 N08 N09 2.83e-02
L10 N09 N10 2.44e-10
R10 N09 N10 2.37e-02
C11 N10 N11 6.24e-06
L11 N10 N11 1.12e-10
R11 N10 N11 2.09e-02
C12 N11 N12 4.00e-06
L12 N11 N12 7.01e-11
R12 N11 N12 1.47e-02
C13 N12 N13 3.11e-11
L13 N12 N13 4.51e-11
R13 N12 N13 7.47e+00
C14 N13 Port2 1.77e-12
L14 N13 Port2 2.69e-10
R14 N13 Port2 6.80e+01
.ENDS GRT32DC81H335KE01

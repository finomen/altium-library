*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ32ER71H475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71H475KE11 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.88e-11
R03 N02 N03 3.85e-03
C04 N03 N04 4.48e-04
R04 N03 N04 3.92e+00
C05 N04 N05 5.72e-04
R05 N04 N05 3.20e-01
C06 N05 N06 5.05e-04
R06 N05 N06 4.41e-02
C07 N06 N07 3.76e-04
R07 N06 N07 7.45e-03
L08 N07 N08 4.33e-11
R08 N07 N08 3.47e-02
L09 N08 N09 3.82e-10
R09 N08 N09 2.55e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.10e-10
R10 N09 N10 1.39e-02
C11 N10 N11 7.01e-06
L11 N10 N11 6.83e-11
R11 N10 N11 9.25e-03
C12 N11 N12 2.14e-11
L12 N11 N12 8.01e-11
R12 N11 N12 4.66e+00
C13 N12 Port2 2.82e-12
L13 N12 Port2 1.77e-10
R13 N12 Port2 7.33e+01
.ENDS GRJ32ER71H475KE11

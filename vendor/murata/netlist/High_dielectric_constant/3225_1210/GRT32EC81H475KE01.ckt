*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRT32EC81H475KE01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32EC81H475KE01 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.31e-10
R03 N02 N03 2.13e-03
C04 N03 N04 5.56e-04
R04 N03 N04 9.93e+00
C05 N04 N05 6.32e-04
R05 N04 N05 8.47e-01
C06 N05 N06 5.88e-04
R06 N05 N06 1.23e-01
C07 N06 N07 6.50e-04
R07 N06 N07 1.46e-02
C08 N07 N08 4.72e-04
R08 N07 N08 2.84e-03
L09 N08 N09 2.55e-11
R09 N08 N09 4.00e-02
L10 N09 N10 3.31e-10
R10 N09 N10 2.49e-02
C11 N10 N11 7.67e-06
L11 N10 N11 1.48e-10
R11 N10 N11 2.30e-02
C12 N11 N12 5.89e-06
L12 N11 N12 7.78e-11
R12 N11 N12 1.35e-02
C13 N12 N13 9.62e-12
L13 N12 N13 7.00e-11
R13 N12 N13 7.94e+00
C14 N13 Port2 3.74e-12
L14 N13 Port2 9.96e-11
R14 N13 Port2 8.51e+01
.ENDS GRT32EC81H475KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/6.80e+00[uF]/25[V]
* Murata P/N :GRT32NR61E685KE01
* Property : C = 6.80e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32NR61E685KE01 Port1 Port2
C01 Port1 N01 5.17e-06
R01 Port1 N01 7.35e+06
L02 N01 N02 1.44e-10
R03 N02 N03 2.99e-03
C04 N03 N04 1.49e-04
R04 N03 N04 1.09e+01
C05 N04 N05 1.85e-04
R05 N04 N05 1.18e+00
C06 N05 N06 1.54e-04
R06 N05 N06 2.05e-01
C07 N06 N07 1.30e-04
R07 N06 N07 3.62e-02
C08 N07 N08 9.61e-05
R08 N07 N08 7.19e-03
L09 N08 N09 1.11e-11
R09 N08 N09 6.78e-02
L10 N09 N10 2.79e-11
R10 N09 N10 2.57e-02
L11 N10 N11 2.31e-10
R11 N10 N11 2.35e-02
C12 N11 N12 9.29e-06
L12 N11 N12 9.82e-11
R12 N11 N12 1.21e-02
C13 N12 N13 4.40e-06
L13 N12 N13 8.50e-11
R13 N12 N13 1.26e-02
C14 N13 N14 1.28e-11
L14 N13 N14 5.93e-11
R14 N13 N14 1.45e+01
C15 N14 Port2 4.08e-12
L15 N14 Port2 1.00e-10
R15 N14 Port2 2.49e+01
.ENDS GRT32NR61E685KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GRJ32DR72A225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72A225ME11 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 6.64e-11
R03 N02 N03 8.32e-03
C04 N03 N04 3.05e-04
R04 N03 N04 3.43e+00
C05 N04 N05 3.42e-04
R05 N04 N05 3.39e-01
C06 N05 N06 3.28e-04
R06 N05 N06 5.08e-02
C07 N06 N07 3.15e-04
R07 N06 N07 1.13e-02
C08 N07 N08 2.66e-04
R08 N07 N08 1.73e-03
L09 N08 N09 3.40e-11
R09 N08 N09 5.09e-02
L10 N09 N10 2.94e-10
R10 N09 N10 3.38e-02
C11 N10 N11 5.09e-06
L11 N10 N11 9.08e-11
R11 N10 N11 2.04e-02
C12 N11 N12 2.30e-06
L12 N11 N12 6.51e-11
R12 N11 N12 1.57e-02
C13 N12 N13 2.11e-11
L13 N12 N13 8.26e-11
R13 N12 N13 7.98e+00
C14 N13 Port2 2.18e-12
L14 N13 Port2 2.43e-10
R14 N13 Port2 6.55e+01
.ENDS GRJ32DR72A225ME11

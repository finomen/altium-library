*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GCJ32QR72E683KXJ1
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32QR72E683KXJ1 Port1 Port2
C01 Port1 N01 6.86e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 3.80e-10
R03 N02 N03 2.96e-02
C04 N03 N04 6.51e-06
R04 N03 N04 2.70e+02
C05 N04 N05 8.02e-06
R05 N04 N05 4.23e+01
C06 N05 N06 6.70e-06
R06 N05 N06 9.15e+00
C07 N06 N07 6.11e-06
R07 N06 N07 1.64e+00
C08 N07 N08 5.03e-06
R08 N07 N08 3.51e-01
C09 N08 N09 3.48e-06
R09 N08 N09 5.20e-02
L10 N09 N10 2.33e-11
R10 N09 N10 9.40e-02
L11 N10 N11 8.87e-11
R11 N10 N11 6.53e-02
C12 N11 N12 3.39e-07
L12 N11 N12 1.94e-11
R12 N11 N12 2.71e-02
C13 N12 N13 6.19e-08
L13 N12 N13 2.94e-11
R13 N12 N13 3.67e-02
C14 N13 Port2 1.25e-11
L14 N13 Port2 1.45e-10
R14 N13 Port2 8.36e+00
.ENDS GCJ32QR72E683KXJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ32ER71E106KE11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71E106KE11 Port1 Port2
C01 Port1 N01 9.52e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.87e-11
R03 N02 N03 3.25e-03
C04 N03 N04 1.22e-03
R04 N03 N04 1.79e+00
C05 N04 N05 1.35e-03
R05 N04 N05 1.83e-01
C06 N05 N06 1.11e-03
R06 N05 N06 3.13e-02
C07 N06 N07 8.78e-04
R07 N06 N07 3.13e-03
L08 N07 N08 1.61e-11
R08 N07 N08 4.44e-02
L09 N08 N09 5.40e-11
R09 N08 N09 3.00e-02
L10 N09 N10 5.98e-10
R10 N09 N10 2.26e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.24e-10
R11 N10 N11 9.33e-03
C12 N11 N12 2.01e-05
L12 N11 N12 6.07e-11
R12 N11 N12 6.27e-03
C13 N12 N13 1.71e-11
L13 N12 N13 5.55e-11
R13 N12 N13 4.44e+00
C14 N13 Port2 2.86e-12
L14 N13 Port2 1.31e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ32ER71E106KE11

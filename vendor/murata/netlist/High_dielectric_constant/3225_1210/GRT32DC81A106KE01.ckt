*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X6S(-55to105[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT32DC81A106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DC81A106KE01 Port1 Port2
C01 Port1 N01 9.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 4.75e-11
R03 N02 N03 1.69e-03
C04 N03 N04 1.02e-03
R04 N03 N04 3.74e+00
C05 N04 N05 1.24e-03
R05 N04 N05 3.18e-01
C06 N05 N06 1.08e-03
R06 N05 N06 5.66e-02
C07 N06 N07 1.30e-03
R07 N06 N07 6.56e-03
C08 N07 N08 8.85e-04
R08 N07 N08 1.61e-03
L09 N08 N09 2.51e-11
R09 N08 N09 3.29e-02
L10 N09 N10 4.24e-10
R10 N09 N10 1.55e-02
L11 N10 N11 1.92e-11
R11 N10 N11 4.14e-03
C12 N11 N12 1.86e-05
L12 N11 N12 1.29e-10
R12 N11 N12 9.47e-03
C13 N12 N13 2.05e-05
L13 N12 N13 5.01e-11
R13 N12 N13 6.18e-03
C14 N13 N14 1.30e-11
L14 N13 N14 8.33e-11
R14 N13 N14 8.03e+00
C15 N14 Port2 2.30e-12
L15 N14 Port2 1.68e-10
R15 N14 Port2 8.13e+01
.ENDS GRT32DC81A106KE01

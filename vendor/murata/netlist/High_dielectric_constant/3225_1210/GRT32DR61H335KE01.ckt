*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/3.30e+00[uF]/50[V]
* Murata P/N :GRT32DR61H335KE01
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32DR61H335KE01 Port1 Port2
C01 Port1 N01 3.27e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 9.11e-11
R03 N02 N03 2.35e-03
C04 N03 N04 6.52e-04
R04 N03 N04 3.35e+00
C05 N04 N05 4.83e-04
R05 N04 N05 5.89e-01
C06 N05 N06 4.72e-04
R06 N05 N06 9.60e-02
C07 N06 N07 4.61e-04
R07 N06 N07 1.70e-02
C08 N07 N08 2.86e-04
R08 N07 N08 3.74e-03
L09 N08 N09 9.21e-12
R09 N08 N09 6.43e-02
L10 N09 N10 2.25e-10
R10 N09 N10 2.64e-02
L11 N10 N11 1.82e-11
R11 N10 N11 1.97e-02
C12 N11 N12 5.53e-06
L12 N11 N12 1.28e-10
R12 N11 N12 2.26e-02
C13 N12 N13 3.14e-06
L13 N12 N13 8.92e-11
R13 N12 N13 1.73e-02
C14 N13 N14 1.77e-11
L14 N13 N14 7.05e-11
R14 N13 N14 1.43e+01
C15 N14 Port2 2.86e-12
L15 N14 Port2 1.88e-10
R15 N14 Port2 5.62e+01
.ENDS GRT32DR61H335KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J223KXJ1
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J223KXJ1 Port1 Port2
C01 Port1 N01 2.24e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 3.45e-10
R03 N02 N03 4.08e-02
C04 N03 N04 2.50e-06
R04 N03 N04 7.94e+02
C05 N04 N05 2.94e-06
R05 N04 N05 1.52e+02
C06 N05 N06 2.55e-06
R06 N05 N06 3.41e+01
C07 N06 N07 2.40e-06
R07 N06 N07 6.95e+00
C08 N07 N08 2.03e-06
R08 N07 N08 1.44e+00
C09 N08 N09 1.70e-06
R09 N08 N09 3.18e-01
C10 N09 N10 1.15e-06
R10 N09 N10 6.07e-02
L11 N10 N11 3.82e-11
R11 N10 N11 2.20e-01
L12 N11 N12 7.24e-11
R12 N11 N12 1.95e-01
C13 N12 N13 7.82e-08
L13 N12 N13 2.45e-11
R13 N12 N13 7.78e-02
C14 N13 N14 1.54e-08
L14 N13 N14 4.20e-11
R14 N13 N14 1.06e-01
C15 N14 Port2 1.50e-11
L15 N14 Port2 1.13e-10
R15 N14 Port2 7.11e+00
.ENDS GCJ32DR72J223KXJ1

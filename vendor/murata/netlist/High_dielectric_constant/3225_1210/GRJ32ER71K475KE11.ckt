*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/4.70e+00[uF]/80[V]
* Murata P/N :GRJ32ER71K475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32ER71K475KE11 Port1 Port2
C01 Port1 N01 4.41e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 5.02e-11
R03 N02 N03 6.63e-03
C04 N03 N04 4.86e-04
R04 N03 N04 3.78e+00
C05 N04 N05 4.91e-04
R05 N04 N05 2.63e-01
C06 N05 N06 4.74e-04
R06 N05 N06 2.71e-02
C07 N06 N07 3.86e-04
R07 N06 N07 3.45e-03
L08 N07 N08 4.92e-11
R08 N07 N08 4.93e-02
L09 N08 N09 4.20e-10
R09 N08 N09 2.29e-02
C10 N09 N10 1.07e-05
L10 N09 N10 1.12e-10
R10 N09 N10 1.40e-02
C11 N10 N11 8.92e-06
L11 N10 N11 5.41e-11
R11 N10 N11 9.24e-03
C12 N11 N12 1.82e-11
L12 N11 N12 7.47e-11
R12 N11 N12 6.00e+00
C13 N12 Port2 1.95e-12
L13 N12 Port2 2.22e-10
R13 N12 Port2 9.98e+01
.ENDS GRJ32ER71K475KE11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X5R(-55to85[deg])/2.20e+01[uF]/25[V]
* Murata P/N :GRT32ER61E226KE13
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT32ER61E226KE13 Port1 Port2
C01 Port1 N01 1.71e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.03e-10
R03 N02 N03 2.44e-03
C04 N03 N04 6.44e-04
R04 N03 N04 1.53e+01
C05 N04 N05 1.43e-03
R05 N04 N05 2.15e+00
C06 N05 N06 7.84e-04
R06 N05 N06 1.06e+00
C07 N06 N07 4.88e-04
R07 N06 N07 2.26e-01
C08 N07 N08 5.04e-04
R08 N07 N08 2.73e-02
C09 N08 N09 3.78e-04
R09 N08 N09 5.28e-03
L10 N09 N10 4.43e-11
R10 N09 N10 2.46e-02
L11 N10 N11 4.91e-10
R11 N10 N11 1.60e-02
C12 N11 N12 3.68e-05
L12 N11 N12 1.27e-10
R12 N11 N12 8.28e-03
C13 N12 N13 2.21e-05
L13 N12 N13 9.59e-11
R13 N12 N13 6.93e-03
C14 N13 N14 2.20e-11
L14 N13 N14 8.30e-11
R14 N13 N14 8.55e+00
C15 N14 Port2 2.03e-12
L15 N14 Port2 2.34e-10
R15 N14 Port2 6.73e+01
.ENDS GRT32ER61E226KE13

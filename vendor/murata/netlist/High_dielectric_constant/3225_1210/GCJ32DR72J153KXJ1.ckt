*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GCJ32DR72J153KXJ1
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DR72J153KXJ1 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 3.27e-10
R03 N02 N03 4.86e-02
C04 N03 N04 1.55e-06
R04 N03 N04 1.18e+03
C05 N04 N05 1.86e-06
R05 N04 N05 2.15e+02
C06 N05 N06 1.59e-06
R06 N05 N06 4.71e+01
C07 N06 N07 1.51e-06
R07 N06 N07 8.97e+00
C08 N07 N08 1.25e-06
R08 N07 N08 1.79e+00
C09 N08 N09 8.85e-07
R09 N08 N09 3.93e-01
C10 N09 N10 6.26e-07
R10 N09 N10 5.54e-02
L11 N10 N11 4.83e-11
R11 N10 N11 2.69e-01
L12 N11 N12 8.13e-11
R12 N11 N12 2.00e-01
C13 N12 N13 5.17e-08
L13 N12 N13 3.14e-11
R13 N12 N13 1.04e-01
C14 N13 N14 1.29e-08
L14 N13 N14 4.17e-11
R14 N13 N14 1.21e-01
C15 N14 Port2 9.92e-12
L15 N14 Port2 2.53e-10
R15 N14 Port2 2.15e+01
.ENDS GCJ32DR72J153KXJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :GRJ32DR72J333KWJ1
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32DR72J333KWJ1 Port1 Port2
C01 Port1 N01 3.40e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 4.02e-10
R03 N02 N03 3.10e-02
C04 N03 N04 4.32e-06
R04 N03 N04 4.96e+02
C05 N04 N05 4.54e-06
R05 N04 N05 1.26e+02
C06 N05 N06 4.10e-06
R06 N05 N06 2.74e+01
C07 N06 N07 3.88e-06
R07 N06 N07 5.95e+00
C08 N07 N08 3.41e-06
R08 N07 N08 1.27e+00
C09 N08 N09 3.00e-06
R09 N08 N09 3.07e-01
C10 N09 N10 1.89e-06
R10 N09 N10 5.72e-02
L11 N10 N11 1.11e-11
R11 N10 N11 1.33e-01
L12 N11 N12 7.84e-11
R12 N11 N12 1.31e-01
C13 N12 N13 1.02e-07
L13 N12 N13 4.45e-11
R13 N12 N13 1.01e-01
C14 N13 N14 2.28e-08
L14 N13 N14 6.82e-11
R14 N13 N14 1.18e-01
C15 N14 Port2 1.45e-11
L15 N14 Port2 1.63e-10
R15 N14 Port2 1.22e+01
.ENDS GRJ32DR72J333KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ32EL81E475KA01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32EL81E475KA01 Port1 Port2
C01 Port1 N01 4.67e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.13e-10
R03 N02 N03 4.16e-03
C04 N03 N04 1.13e-03
R04 N03 N04 3.43e+00
C05 N04 N05 6.55e-04
R05 N04 N05 8.39e-01
C06 N05 N06 5.54e-04
R06 N05 N06 1.36e-01
C07 N06 N07 5.48e-04
R07 N06 N07 1.77e-02
C08 N07 N08 4.72e-04
R08 N07 N08 3.29e-03
L09 N08 N09 1.68e-11
R09 N08 N09 6.76e-02
L10 N09 N10 5.25e-11
R10 N09 N10 2.63e-02
L11 N10 N11 3.75e-10
R11 N10 N11 2.21e-02
C12 N11 N12 9.12e-06
L12 N11 N12 1.33e-10
R12 N11 N12 1.47e-02
C13 N12 N13 8.15e-06
L13 N12 N13 6.02e-11
R13 N12 N13 1.02e-02
C14 N13 N14 3.11e-11
L14 N13 N14 6.07e-11
R14 N13 N14 5.24e+00
C15 N14 Port2 2.58e-12
L15 N14 Port2 1.89e-10
R15 N14 Port2 9.63e+01
.ENDS GCJ32EL81E475KA01

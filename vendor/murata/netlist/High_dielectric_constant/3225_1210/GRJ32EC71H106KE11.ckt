*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7S(-55to125[deg])/1.00e+01[uF]/50[V]
* Murata P/N :GRJ32EC71H106KE11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ32EC71H106KE11 Port1 Port2
C01 Port1 N01 9.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 5.75e-11
R03 N02 N03 6.36e-03
C04 N03 N04 2.11e-03
R04 N03 N04 1.30e+00
C05 N04 N05 1.82e-03
R05 N04 N05 2.05e-01
C06 N05 N06 1.36e-03
R06 N05 N06 3.51e-02
C07 N06 N07 1.86e-03
R07 N06 N07 2.44e-03
L08 N07 N08 1.37e-11
R08 N07 N08 6.00e-02
L09 N08 N09 7.76e-11
R09 N08 N09 3.76e-02
L10 N09 N10 5.46e-10
R10 N09 N10 1.90e-02
C11 N10 N11 2.25e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.54e-03
C12 N11 N12 2.05e-05
L12 N11 N12 6.70e-11
R12 N11 N12 6.31e-03
C13 N12 N13 3.36e-11
L13 N12 N13 4.44e-11
R13 N12 N13 2.71e+00
C14 N13 Port2 2.07e-12
L14 N13 Port2 1.91e-10
R14 N13 Port2 1.08e+02
.ENDS GRJ32EC71H106KE11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X8L(-55to150[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ32DL8EL225KA07
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ32DL8EL225KA07 Port1 Port2
C01 Port1 N01 2.15e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.07e-10
R03 N02 N03 3.81e-03
C04 N03 N04 4.07e-04
R04 N03 N04 1.83e+00
C05 N04 N05 3.15e-04
R05 N04 N05 3.27e-01
C06 N05 N06 3.01e-04
R06 N05 N06 4.55e-02
C07 N06 N07 2.30e-04
R07 N06 N07 7.15e-03
L08 N07 N08 7.20e-12
R08 N07 N08 4.80e-02
L09 N08 N09 2.32e-10
R09 N08 N09 3.15e-02
L10 N09 N10 2.21e-11
R10 N09 N10 2.77e-02
C11 N10 N11 4.14e-06
L11 N10 N11 1.18e-10
R11 N10 N11 2.23e-02
C12 N11 N12 2.62e-06
L12 N11 N12 6.07e-11
R12 N11 N12 1.58e-02
C13 N12 N13 2.32e-11
L13 N12 N13 6.80e-11
R13 N12 N13 8.71e+00
C14 N13 Port2 2.62e-12
L14 N13 Port2 2.02e-10
R14 N13 Port2 8.32e+01
.ENDS GCJ32DL8EL225KA07

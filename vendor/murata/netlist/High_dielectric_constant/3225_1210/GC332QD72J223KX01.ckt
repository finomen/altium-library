*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7T(-55to125[deg])/2.20e-02[uF]/630[V]
* Murata P/N :GC332QD72J223KX01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC332QD72J223KX01 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 3.40e-10
R03 N02 N03 2.11e-02
C04 N03 N04 7.68e-06
R04 N03 N04 2.57e+02
C05 N04 N05 1.08e-05
R05 N04 N05 3.03e+01
C06 N05 N06 9.90e-06
R06 N05 N06 6.34e+00
C07 N06 N07 8.77e-06
R07 N06 N07 1.22e+00
C08 N07 N08 7.33e-06
R08 N07 N08 2.20e-01
C09 N08 N09 4.40e-06
R09 N08 N09 5.51e-02
L10 N09 N10 7.25e-11
R10 N09 N10 1.22e-01
L11 N10 N11 3.06e-11
R11 N10 N11 3.96e-02
C12 N11 N12 7.44e-08
L12 N11 N12 3.03e-11
R12 N11 N12 1.02e-01
C13 N12 N13 2.28e-08
L13 N12 N13 3.33e-11
R13 N12 N13 9.42e-02
C14 N13 N14 4.35e-10
L14 N13 N14 1.52e-11
R14 N13 N14 2.61e-01
C15 N14 Port2 1.10e-11
L15 N14 Port2 2.07e-10
R15 N14 Port2 2.39e+01
.ENDS GC332QD72J223KX01

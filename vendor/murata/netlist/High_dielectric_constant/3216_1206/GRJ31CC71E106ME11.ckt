*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CC71E106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC71E106ME11 Port1 Port2
C01 Port1 N01 9.55e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.18e-11
R03 N02 N03 6.29e-03
C04 N03 N04 7.06e-04
R04 N03 N04 8.06e+00
C05 N04 N05 1.61e-03
R05 N04 N05 3.56e-01
C06 N05 N06 1.29e-03
R06 N05 N06 5.20e-02
C07 N06 N07 1.25e-03
R07 N06 N07 4.04e-03
L08 N07 N08 1.24e-11
R08 N07 N08 5.53e-02
L09 N08 N09 5.61e-11
R09 N08 N09 3.44e-02
L10 N09 N10 5.35e-10
R10 N09 N10 1.94e-02
C11 N10 N11 1.98e-05
L11 N10 N11 1.66e-10
R11 N10 N11 7.88e-03
C12 N11 N12 2.72e-05
L12 N11 N12 5.30e-11
R12 N11 N12 6.45e-03
C13 N12 Port2 1.00e-12
L13 N12 Port2 3.67e-10
R13 N12 Port2 1.51e+02
.ENDS GRJ31CC71E106ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ31ML81E474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81E474MA01 Port1 Port2
C01 Port1 N01 4.51e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 3.13e-10
R03 N02 N03 3.82e-02
C04 N03 N04 5.78e-05
R04 N03 N04 6.89e+01
C05 N04 N05 7.67e-05
R05 N04 N05 7.55e+00
C06 N05 N06 5.93e-05
R06 N05 N06 1.22e+00
C07 N06 N07 5.70e-05
R07 N06 N07 1.31e-01
C08 N07 N08 2.93e-05
R08 N07 N08 3.60e-02
L09 N08 N09 2.67e-11
R09 N08 N09 1.05e-01
L10 N09 N10 2.16e-10
R10 N09 N10 6.52e-02
C11 N10 N11 1.26e-06
L11 N10 N11 6.80e-11
R11 N10 N11 1.81e-02
C12 N11 N12 4.92e-07
L12 N11 N12 6.34e-11
R12 N11 N12 2.26e-02
C13 N12 N13 1.82e-11
L13 N12 N13 6.82e-11
R13 N12 N13 5.71e+00
C14 N13 Port2 2.47e-12
L14 N13 Port2 1.40e-10
R14 N13 Port2 2.98e+01
.ENDS GCJ31ML81E474MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :LLL315R71H103MA11
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71H103MA11 Port1 Port2
C01 Port1 N01 9.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.73e-11
R03 N02 N03 3.45e-02
C04 N03 N04 1.16e-06
R04 N03 N04 2.21e+03
C05 N04 N05 2.12e-06
R05 N04 N05 2.53e+02
C06 N05 N06 1.54e-06
R06 N05 N06 7.48e+01
C07 N06 N07 1.53e-06
R07 N06 N07 1.33e+01
C08 N07 N08 1.11e-06
R08 N07 N08 2.35e+00
C09 N08 N09 1.13e-06
R09 N08 N09 3.09e-01
C10 N09 N10 1.05e-06
R10 N09 N10 8.06e-02
C11 N10 N11 5.79e-07
R11 N10 N11 4.00e-02
L12 N11 N12 1.57e-11
R12 N11 N12 1.07e-01
C13 N12 N13 3.38e-08
L13 N12 N13 8.69e-12
R13 N12 N13 4.20e-02
C14 N13 N14 4.34e-09
L14 N13 N14 2.00e-11
R14 N13 N14 6.54e-02
C15 N14 N15 3.16e-11
L15 N14 N15 6.07e-11
R15 N14 N15 3.85e+00
C16 N15 Port2 9.50e-12
L16 N15 Port2 5.45e-11
R16 N15 Port2 5.85e+00
.ENDS LLL315R71H103MA11

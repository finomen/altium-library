*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GCJ31CR72J153KXJ3
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72J153KXJ3 Port1 Port2
C01 Port1 N01 1.53e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.80e-10
R03 N02 N03 5.69e-02
C04 N03 N04 1.71e-06
R04 N03 N04 1.14e+03
C05 N04 N05 1.96e-06
R05 N04 N05 2.31e+02
C06 N05 N06 1.69e-06
R06 N05 N06 5.13e+01
C07 N06 N07 1.60e-06
R07 N06 N07 1.04e+01
C08 N07 N08 1.38e-06
R08 N07 N08 2.13e+00
C09 N08 N09 1.01e-06
R09 N08 N09 5.06e-01
C10 N09 N10 6.94e-07
R10 N09 N10 7.90e-02
L11 N10 N11 7.22e-11
R11 N10 N11 3.03e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.96e-01
C13 N12 N13 1.31e-07
L13 N12 N13 1.77e-11
R13 N12 N13 5.92e-02
C14 N13 N14 1.54e-08
L14 N13 N14 6.01e-11
R14 N13 N14 1.18e-01
C15 N14 Port2 1.68e-11
L15 N14 Port2 1.27e-10
R15 N14 Port2 9.42e+00
.ENDS GCJ31CR72J153KXJ3

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/6.80e+00[uF]/16[V]
* Murata P/N :GRT31MR61C685KE01
* Property : C = 6.80e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31MR61C685KE01 Port1 Port2
C01 Port1 N01 5.01e-06
R01 Port1 N01 7.35e+06
L02 N01 N02 7.57e-11
R03 N02 N03 4.94e-03
C04 N03 N04 1.84e-04
R04 N03 N04 2.10e+01
C05 N04 N05 1.86e-04
R05 N04 N05 2.72e+00
C06 N05 N06 1.57e-04
R06 N05 N06 4.09e-01
C07 N06 N07 1.28e-04
R07 N06 N07 6.40e-02
C08 N07 N08 9.50e-05
R08 N07 N08 1.05e-02
L09 N08 N09 2.91e-11
R09 N08 N09 9.54e-02
L10 N09 N10 5.35e-11
R10 N09 N10 3.94e-02
L11 N10 N11 2.75e-10
R11 N10 N11 2.45e-02
C12 N11 N12 2.58e-05
L12 N11 N12 3.95e-11
R12 N11 N12 4.87e-03
C13 N12 N13 4.49e-06
L13 N12 N13 1.03e-10
R13 N12 N13 8.89e-03
C14 N13 N14 1.48e-11
L14 N13 N14 7.03e-11
R14 N13 N14 6.88e+00
C15 N14 Port2 1.53e-12
L15 N14 Port2 2.41e-10
R15 N14 Port2 1.09e+02
.ENDS GRT31MR61C685KE01

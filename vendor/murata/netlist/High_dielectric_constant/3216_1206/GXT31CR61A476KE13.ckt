*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GXT31CR61A476KE13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CR61A476KE13 Port1 Port2
C01 Port1 N01 3.31e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.42e-10
R03 N02 N03 2.16e-03
C04 N03 N04 9.30e-04
R04 N03 N04 4.44e+00
C05 N04 N05 1.19e-03
R05 N04 N05 5.95e-01
C06 N05 N06 9.53e-04
R06 N05 N06 1.12e-01
C07 N06 N07 9.44e-04
R07 N06 N07 1.73e-02
C08 N07 N08 6.74e-04
R08 N07 N08 3.68e-03
L09 N08 N09 2.34e-11
R09 N08 N09 4.82e-02
L10 N09 N10 7.25e-11
R10 N09 N10 2.22e-02
L11 N10 N11 4.61e-10
R11 N10 N11 1.15e-02
C12 N11 N12 9.08e-05
L12 N11 N12 1.15e-10
R12 N11 N12 2.61e-03
C13 N12 N13 4.57e-05
L13 N12 N13 1.17e-10
R13 N12 N13 3.48e-03
C14 N13 N14 1.82e-11
L14 N13 N14 7.09e-11
R14 N13 N14 7.18e+00
C15 N14 Port2 1.99e-12
L15 N14 Port2 1.92e-10
R15 N14 Port2 9.80e+01
.ENDS GXT31CR61A476KE13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GRT31CC80J476KE13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC80J476KE13 Port1 Port2
C01 Port1 N01 3.31e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 8.58e-11
R03 N02 N03 2.25e-03
C04 N03 N04 7.75e-04
R04 N03 N04 6.17e+00
C05 N04 N05 9.76e-04
R05 N04 N05 5.42e-01
C06 N05 N06 1.16e-03
R06 N05 N06 7.11e-02
C07 N06 N07 9.62e-04
R07 N06 N07 2.05e-02
C08 N07 N08 6.82e-04
R08 N07 N08 3.86e-03
L09 N08 N09 2.10e-11
R09 N08 N09 6.55e-02
L10 N09 N10 8.12e-11
R10 N09 N10 2.58e-02
L11 N10 N11 5.28e-10
R11 N10 N11 1.11e-02
C12 N11 N12 9.04e-05
L12 N11 N12 1.21e-10
R12 N11 N12 2.84e-03
C13 N12 N13 6.21e-05
L13 N12 N13 8.75e-11
R13 N12 N13 2.96e-03
C14 N13 N14 1.14e-11
L14 N13 N14 8.24e-11
R14 N13 N14 1.01e+01
C15 N14 Port2 1.58e-12
L15 N14 Port2 2.29e-10
R15 N14 Port2 2.43e+02
.ENDS GRT31CC80J476KE13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.70e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H274KA01
* Property : C = 2.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H274KA01 Port1 Port2
C01 Port1 N01 2.74e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.73e-10
R03 N02 N03 4.19e-02
C04 N03 N04 2.85e-05
R04 N03 N04 1.55e+02
C05 N04 N05 4.22e-05
R05 N04 N05 1.58e+01
C06 N05 N06 3.26e-05
R06 N05 N06 2.04e+00
C07 N06 N07 3.15e-05
R07 N06 N07 2.24e-01
C08 N07 N08 1.75e-05
R08 N07 N08 3.25e-02
L09 N08 N09 2.58e-10
R09 N08 N09 7.87e-02
L10 N09 N10 1.80e-11
R10 N09 N10 4.06e-02
C11 N10 N11 2.21e-06
L11 N10 N11 2.86e-11
R11 N10 N11 1.22e-02
C12 N11 N12 4.84e-07
L12 N11 N12 5.53e-11
R12 N11 N12 2.37e-02
C13 N12 N13 1.62e-11
L13 N12 N13 9.39e-11
R13 N12 N13 1.44e+01
C14 N13 N14 2.50e-12
L14 N13 N14 2.93e-10
R14 N13 N14 2.84e+01
C15 N14 Port2 3.53e-12
L15 N14 Port2 1.14e-10
R15 N14 Port2 3.42e+01
.ENDS GCJ31MR71H274KA01

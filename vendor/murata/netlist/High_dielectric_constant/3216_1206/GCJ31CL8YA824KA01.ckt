*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/8.20e-01[uF]/35[V]
* Murata P/N :GCJ31CL8YA824KA01
* Property : C = 8.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA824KA01 Port1 Port2
C01 Port1 N01 8.03e-07
R01 Port1 N01 6.10e+08
L02 N01 N02 1.90e-10
R03 N02 N03 7.46e-03
C04 N03 N04 9.89e-05
R04 N03 N04 2.49e+01
C05 N04 N05 1.27e-04
R05 N04 N05 1.98e+00
C06 N05 N06 1.24e-04
R06 N05 N06 2.55e-01
C07 N06 N07 1.79e-04
R07 N06 N07 3.36e-02
C08 N07 N08 6.51e-05
R08 N07 N08 1.67e-02
L09 N08 N09 2.58e-11
R09 N08 N09 5.48e-02
L10 N09 N10 3.30e-10
R10 N09 N10 4.91e-02
C11 N10 N11 2.74e-06
L11 N10 N11 7.07e-11
R11 N10 N11 1.85e-02
C12 N11 N12 1.33e-06
L12 N11 N12 6.09e-11
R12 N11 N12 1.94e-02
C13 N12 N13 9.71e-12
L13 N12 N13 1.53e-10
R13 N12 N13 1.96e+01
C14 N13 Port2 2.49e-12
L14 N13 Port2 2.94e-10
R14 N13 Port2 6.19e+01
.ENDS GCJ31CL8YA824KA01

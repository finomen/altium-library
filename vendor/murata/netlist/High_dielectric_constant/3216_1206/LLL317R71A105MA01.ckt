*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :LLL317R71A105MA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71A105MA01 Port1 Port2
C01 Port1 N01 1.00e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 4.08e-11
R03 N02 N03 2.04e-03
C04 N03 N04 2.35e-04
R04 N03 N04 1.03e+01
C05 N04 N05 1.91e-04
R05 N04 N05 2.01e+00
C06 N05 N06 1.06e-04
R06 N05 N06 4.92e-01
C07 N06 N07 1.06e-04
R07 N06 N07 6.70e-02
C08 N07 N08 1.10e-04
R08 N07 N08 1.00e-02
C09 N08 N09 1.01e-04
R09 N08 N09 2.72e-03
L10 N09 N10 5.52e-12
R10 N09 N10 3.65e-02
L11 N10 N11 6.98e-11
R11 N10 N11 2.63e-02
C12 N11 N12 1.52e-06
L12 N11 N12 3.81e-11
R12 N11 N12 2.74e-02
C13 N12 N13 6.66e-07
L13 N12 N13 2.91e-11
R13 N12 N13 1.85e-02
C14 N13 Port2 9.46e-12
L14 N13 Port2 4.41e-11
R14 N13 Port2 7.77e+00
.ENDS LLL317R71A105MA01

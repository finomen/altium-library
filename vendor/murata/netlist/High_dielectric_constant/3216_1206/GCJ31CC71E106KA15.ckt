*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GCJ31CC71E106KA15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71E106KA15 Port1 Port2
C01 Port1 N01 9.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.16e-10
R03 N02 N03 5.58e-03
C04 N03 N04 1.41e-03
R04 N03 N04 2.26e+00
C05 N04 N05 1.71e-03
R05 N04 N05 2.23e-01
C06 N05 N06 1.43e-03
R06 N05 N06 3.92e-02
C07 N06 N07 1.06e-03
R07 N06 N07 4.09e-03
L08 N07 N08 2.45e-11
R08 N07 N08 6.92e-02
L09 N08 N09 5.02e-11
R09 N08 N09 2.30e-02
L10 N09 N10 4.42e-10
R10 N09 N10 1.76e-02
C11 N10 N11 2.43e-05
L11 N10 N11 1.39e-10
R11 N10 N11 8.52e-03
C12 N11 N12 1.44e-05
L12 N11 N12 1.06e-10
R12 N11 N12 8.54e-03
C13 N12 N13 1.80e-11
L13 N12 N13 5.21e-11
R13 N12 N13 1.25e+01
C14 N13 Port2 1.53e-12
L14 N13 Port2 2.67e-10
R14 N13 Port2 1.43e+02
.ENDS GCJ31CC71E106KA15

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H475KE11 Port1 Port2
C01 Port1 N01 4.35e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.34e-10
R03 N02 N03 7.37e-03
C04 N03 N04 9.15e-04
R04 N03 N04 2.42e+00
C05 N04 N05 8.37e-04
R05 N04 N05 3.40e-01
C06 N05 N06 8.24e-04
R06 N05 N06 4.81e-02
C07 N06 N07 8.98e-04
R07 N06 N07 8.45e-03
C08 N07 N08 5.09e-04
R08 N07 N08 1.67e-03
L09 N08 N09 1.50e-11
R09 N08 N09 7.49e-02
L10 N09 N10 6.58e-11
R10 N09 N10 4.33e-02
L11 N10 N11 5.35e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.44e-05
L12 N11 N12 1.07e-10
R12 N11 N12 8.46e-03
C13 N12 N13 7.84e-06
L13 N12 N13 8.26e-11
R13 N12 N13 7.47e-03
C14 N13 N14 2.27e-11
L14 N13 N14 4.78e-11
R14 N13 N14 3.67e+00
C15 N14 Port2 2.91e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 2.05e+01
.ENDS GRJ31CR71H475KE11

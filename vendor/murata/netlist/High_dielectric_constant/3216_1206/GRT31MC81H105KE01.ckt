*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRT31MC81H105KE01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31MC81H105KE01 Port1 Port2
C01 Port1 N01 9.50e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 7.29e-11
R03 N02 N03 7.58e-03
C04 N03 N04 1.00e-04
R04 N03 N04 7.55e+00
C05 N04 N05 1.30e-04
R05 N04 N05 4.12e-01
C06 N05 N06 8.48e-05
R06 N05 N06 7.15e-02
C07 N06 N07 7.25e-05
R07 N06 N07 9.58e-03
L08 N07 N08 2.70e-11
R08 N07 N08 6.82e-02
L09 N08 N09 2.50e-10
R09 N08 N09 4.43e-02
C10 N09 N10 5.69e-06
L10 N09 N10 3.15e-11
R10 N09 N10 7.71e-03
C11 N10 N11 1.17e-06
L11 N10 N11 6.41e-11
R11 N10 N11 1.40e-02
C12 N11 N12 2.22e-11
L12 N11 N12 9.67e-11
R12 N11 N12 6.40e+00
C13 N12 Port2 1.23e-12
L13 N12 Port2 3.40e-10
R13 N12 Port2 1.35e+02
.ENDS GRT31MC81H105KE01

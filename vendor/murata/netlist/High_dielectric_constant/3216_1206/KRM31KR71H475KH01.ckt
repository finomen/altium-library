*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :KRM31KR71H475KH01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31KR71H475KH01 Port1 Port2
C01 Port1 N01 4.26e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 2.26e-11
R03 N02 N03 6.02e-03
C04 N03 N04 8.90e-04
R04 N03 N04 6.38e-01
C05 N04 N05 8.55e-04
R05 N04 N05 9.74e-02
C06 N05 N06 6.47e-04
R06 N05 N06 1.74e-02
L07 N06 N07 9.14e-11
R07 N06 N07 7.75e-02
L08 N07 N08 5.11e-10
R08 N07 N08 3.05e-02
L09 N08 N09 4.56e-10
R09 N08 N09 5.65e-03
C10 N09 N10 1.45e-05
L10 N09 N10 9.20e-11
R10 N09 N10 8.28e-03
C11 N10 N11 1.14e-05
L11 N10 N11 5.68e-11
R11 N10 N11 8.15e-03
C12 N11 N12 9.44e-13
L12 N11 N12 1.18e-09
R12 N11 N12 5.40e+02
C13 N12 Port2 2.93e-12
L13 N12 Port2 2.02e-10
R13 N12 Port2 4.67e+01
.ENDS KRM31KR71H475KH01

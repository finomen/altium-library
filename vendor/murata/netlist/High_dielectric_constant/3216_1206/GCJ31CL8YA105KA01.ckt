*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/35[V]
* Murata P/N :GCJ31CL8YA105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8YA105KA01 Port1 Port2
C01 Port1 N01 9.96e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.44e-10
R03 N02 N03 9.97e-03
C04 N03 N04 1.38e-04
R04 N03 N04 1.93e+01
C05 N04 N05 1.34e-04
R05 N04 N05 2.84e+00
C06 N05 N06 1.24e-04
R06 N05 N06 4.13e-01
C07 N06 N07 1.11e-04
R07 N06 N07 6.11e-02
C08 N07 N08 7.82e-05
R08 N07 N08 1.10e-02
L09 N08 N09 1.68e-11
R09 N08 N09 9.44e-02
L10 N09 N10 3.22e-10
R10 N09 N10 4.24e-02
L11 N10 N11 3.22e-11
R11 N10 N11 3.23e-02
C12 N11 N12 2.81e-06
L12 N11 N12 9.11e-11
R12 N11 N12 1.94e-02
C13 N12 N13 1.62e-06
L13 N12 N13 6.52e-11
R13 N12 N13 1.74e-02
C14 N13 N14 1.42e-11
L14 N13 N14 8.58e-11
R14 N13 N14 1.39e+01
C15 N14 Port2 2.10e-12
L15 N14 Port2 2.91e-10
R15 N14 Port2 8.38e+01
.ENDS GCJ31CL8YA105KA01

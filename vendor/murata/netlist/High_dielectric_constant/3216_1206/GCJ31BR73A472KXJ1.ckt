*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/1000[V]
* Murata P/N :GCJ31BR73A472KXJ1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR73A472KXJ1 Port1 Port2
C01 Port1 N01 4.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.89e-10
R03 N02 N03 1.26e-01
C04 N03 N04 5.10e-07
R04 N03 N04 3.31e+03
C05 N04 N05 6.28e-07
R05 N04 N05 5.07e+02
C06 N05 N06 5.43e-07
R06 N05 N06 1.08e+02
C07 N06 N07 4.90e-07
R07 N06 N07 2.05e+01
C08 N07 N08 3.95e-07
R08 N07 N08 4.01e+00
C09 N08 N09 3.38e-07
R09 N08 N09 8.49e-01
C10 N09 N10 1.80e-07
R10 N09 N10 1.66e-01
L11 N10 N11 6.50e-11
R11 N10 N11 4.73e-01
L12 N11 N12 5.93e-11
R12 N11 N12 3.04e-01
C13 N12 N13 6.15e-08
L13 N12 N13 8.81e-12
R13 N12 N13 5.78e-02
C14 N13 N14 4.40e-09
L14 N13 N14 3.95e-11
R14 N13 N14 1.82e-01
C15 N14 Port2 1.17e-11
L15 N14 Port2 1.58e-10
R15 N14 Port2 9.05e+00
.ENDS GCJ31BR73A472KXJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.50e+01[uF]/6.3[V]
* Murata P/N :GRT31CR60J156KE01
* Property : C = 1.50e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR60J156KE01 Port1 Port2
C01 Port1 N01 1.19e-05
R01 Port1 N01 3.33e+06
L02 N01 N02 4.19e-11
R03 N02 N03 4.00e-03
C04 N03 N04 3.52e-04
R04 N03 N04 1.17e+01
C05 N04 N05 3.80e-04
R05 N04 N05 1.39e+00
C06 N05 N06 3.32e-04
R06 N05 N06 2.02e-01
C07 N06 N07 2.78e-04
R07 N06 N07 3.08e-02
C08 N07 N08 2.75e-04
R08 N07 N08 4.45e-03
L09 N08 N09 2.01e-11
R09 N08 N09 5.16e-02
L10 N09 N10 5.46e-11
R10 N09 N10 2.41e-02
L11 N10 N11 3.06e-10
R11 N10 N11 1.66e-02
C12 N11 N12 3.22e-05
L12 N11 N12 9.69e-11
R12 N11 N12 4.93e-03
C13 N12 N13 1.24e-05
L13 N12 N13 1.14e-10
R13 N12 N13 6.45e-03
C14 N13 N14 1.75e-11
L14 N13 N14 6.79e-11
R14 N13 N14 9.57e+00
C15 N14 Port2 1.36e-12
L15 N14 Port2 3.16e-10
R15 N14 Port2 2.12e+02
.ENDS GRT31CR60J156KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/3.30e+00[uF]/16[V]
* Murata P/N :GCJ31CL81C335KA01
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81C335KA01 Port1 Port2
C01 Port1 N01 3.17e-06
R01 Port1 N01 1.52e+08
L02 N01 N02 1.62e-10
R03 N02 N03 8.76e-03
C04 N03 N04 4.29e-04
R04 N03 N04 2.08e+00
C05 N04 N05 4.44e-04
R05 N04 N05 2.63e-01
C06 N05 N06 4.34e-04
R06 N05 N06 4.02e-02
C07 N06 N07 2.83e-04
R07 N06 N07 6.92e-03
L08 N07 N08 4.21e-11
R08 N07 N08 3.03e-02
L09 N08 N09 2.94e-10
R09 N08 N09 2.56e-02
L10 N09 N10 8.96e-12
R10 N09 N10 2.55e-02
C11 N10 N11 1.33e-05
L11 N10 N11 6.44e-11
R11 N10 N11 7.27e-03
C12 N11 N12 3.77e-06
L12 N11 N12 9.74e-11
R12 N11 N12 1.07e-02
C13 N12 N13 2.37e-11
L13 N12 N13 8.04e-11
R13 N12 N13 1.21e+01
C14 N13 Port2 1.69e-12
L14 N13 Port2 3.92e-10
R14 N13 Port2 7.29e+01
.ENDS GCJ31CL81C335KA01

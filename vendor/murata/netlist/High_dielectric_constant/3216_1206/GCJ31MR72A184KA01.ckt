*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.80e-01[uF]/100[V]
* Murata P/N :GCJ31MR72A184KA01
* Property : C = 1.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR72A184KA01 Port1 Port2
C01 Port1 N01 1.85e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 8.01e-11
R03 N02 N03 5.94e-02
C04 N03 N04 1.98e-05
R04 N03 N04 2.80e+02
C05 N04 N05 3.14e-05
R05 N04 N05 2.13e+01
C06 N05 N06 2.43e-05
R06 N05 N06 2.74e+00
C07 N06 N07 2.40e-05
R07 N06 N07 2.87e-01
C08 N07 N08 1.30e-05
R08 N07 N08 4.39e-02
L09 N08 N09 1.59e-10
R09 N08 N09 9.32e-02
L10 N09 N10 3.42e-11
R10 N09 N10 8.40e-02
C11 N10 N11 8.12e-07
L11 N10 N11 4.05e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.26e-07
L12 N11 N12 7.06e-11
R12 N11 N12 2.94e-02
C13 N12 N13 9.28e-12
L13 N12 N13 1.03e-10
R13 N12 N13 1.62e+01
C14 N13 Port2 1.26e-12
L14 N13 Port2 3.83e-10
R14 N13 Port2 7.57e+01
.ENDS GCJ31MR72A184KA01

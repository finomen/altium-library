*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :LLL315R71C473MA11
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71C473MA11 Port1 Port2
C01 Port1 N01 4.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.80e-11
R03 N02 N03 1.24e-02
C04 N03 N04 6.01e-06
R04 N03 N04 6.14e+02
C05 N04 N05 9.21e-06
R05 N04 N05 6.29e+01
C06 N05 N06 7.69e-06
R06 N05 N06 1.47e+01
C07 N06 N07 6.64e-06
R07 N06 N07 2.45e+00
C08 N07 N08 5.21e-06
R08 N07 N08 3.43e-01
C09 N08 N09 7.49e-06
R09 N08 N09 3.69e-02
C10 N09 N10 4.73e-06
R10 N09 N10 1.75e-02
C11 N10 N11 4.30e-06
R11 N10 N11 5.74e-03
L12 N11 N12 2.23e-11
R12 N11 N12 8.53e-02
C13 N12 N13 6.05e-08
L13 N12 N13 1.62e-11
R13 N12 N13 2.94e-02
C14 N13 N14 2.02e-08
L14 N13 N14 9.59e-12
R14 N13 N14 1.90e-02
C15 N14 Port2 6.79e-12
L15 N14 Port2 6.86e-11
R15 N14 Port2 9.64e+00
.ENDS LLL315R71C473MA11

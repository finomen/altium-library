*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GCJ31MR71H105MA12
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H105MA12 Port1 Port2
C01 Port1 N01 1.00e-06
R01 Port1 N01 5.00e+08
L02 N01 N02 8.35e-11
R03 N02 N03 1.23e-02
C04 N03 N04 1.13e-04
R04 N03 N04 7.82e+00
C05 N04 N05 1.07e-04
R05 N04 N05 7.94e-01
C06 N05 N06 9.48e-05
R06 N05 N06 9.04e-02
C07 N06 N07 8.75e-05
R07 N06 N07 9.98e-03
C08 N07 N08 6.63e-05
R08 N07 N08 1.29e-03
L09 N08 N09 3.60e-11
R09 N08 N09 5.25e-02
L10 N09 N10 2.56e-10
R10 N09 N10 4.20e-02
C11 N10 N11 3.64e-06
L11 N10 N11 5.78e-11
R11 N10 N11 1.26e-02
C12 N11 N12 1.00e-06
L12 N11 N12 8.34e-11
R12 N11 N12 1.75e-02
C13 N12 Port2 9.41e-13
L13 N12 Port2 4.54e-10
R13 N12 Port2 9.01e+01
.ENDS GCJ31MR71H105MA12

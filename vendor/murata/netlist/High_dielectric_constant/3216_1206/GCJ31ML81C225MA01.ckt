*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/2.20e+00[uF]/16[V]
* Murata P/N :GCJ31ML81C225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31ML81C225MA01 Port1 Port2
C01 Port1 N01 2.09e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.05e-10
R03 N02 N03 9.09e-03
C04 N03 N04 2.61e-04
R04 N03 N04 3.12e+00
C05 N04 N05 2.75e-04
R05 N04 N05 3.74e-01
C06 N05 N06 2.58e-04
R06 N05 N06 5.20e-02
C07 N06 N07 1.78e-04
R07 N06 N07 8.58e-03
L08 N07 N08 1.46e-11
R08 N07 N08 7.22e-02
L09 N08 N09 3.66e-11
R09 N08 N09 3.57e-02
L10 N09 N10 3.04e-10
R10 N09 N10 3.44e-02
C11 N10 N11 7.50e-06
L11 N10 N11 7.28e-11
R11 N10 N11 1.07e-02
C12 N11 N12 2.47e-06
L12 N11 N12 9.55e-11
R12 N11 N12 1.47e-02
C13 N12 N13 2.45e-11
L13 N12 N13 4.91e-11
R13 N12 N13 8.55e+00
C14 N13 Port2 1.39e-12
L14 N13 Port2 3.05e-10
R14 N13 Port2 1.56e+02
.ENDS GCJ31ML81C225MA01

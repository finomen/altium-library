*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRT31CR61A106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61A106KE01 Port1 Port2
C01 Port1 N01 9.09e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.00e-10
R03 N02 N03 2.65e-03
C04 N03 N04 1.10e-03
R04 N03 N04 4.23e+00
C05 N04 N05 1.19e-03
R05 N04 N05 4.20e-01
C06 N05 N06 1.02e-03
R06 N05 N06 6.02e-02
C07 N06 N07 1.90e-03
R07 N06 N07 8.05e-03
C08 N07 N08 8.61e-04
R08 N07 N08 3.44e-03
L09 N08 N09 3.25e-11
R09 N08 N09 1.18e-01
L10 N09 N10 9.35e-11
R10 N09 N10 4.84e-02
L11 N10 N11 4.37e-10
R11 N10 N11 1.68e-02
C12 N11 N12 3.34e-05
L12 N11 N12 9.17e-11
R12 N11 N12 4.76e-03
C13 N12 N13 1.29e-05
L13 N12 N13 1.10e-10
R13 N12 N13 5.58e-03
C14 N13 N14 1.71e-11
L14 N13 N14 7.87e-11
R14 N13 N14 4.92e+00
C15 N14 Port2 1.64e-12
L15 N14 Port2 2.66e-10
R15 N14 Port2 1.53e+02
.ENDS GRT31CR61A106KE01

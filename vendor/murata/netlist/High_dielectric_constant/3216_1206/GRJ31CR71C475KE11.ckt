*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRJ31CR71C475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71C475KE11 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.87e-10
R03 N02 N03 1.24e-02
C04 N03 N04 6.04e-04
R04 N03 N04 8.39e+00
C05 N04 N05 6.50e-04
R05 N04 N05 8.52e-01
C06 N05 N06 5.47e-04
R06 N05 N06 1.18e-01
C07 N06 N07 5.79e-04
R07 N06 N07 1.18e-02
C08 N07 N08 3.80e-04
R08 N07 N08 2.61e-03
L09 N08 N09 2.33e-11
R09 N08 N09 8.26e-02
L10 N09 N10 5.37e-11
R10 N09 N10 3.10e-02
L11 N10 N11 4.92e-10
R11 N10 N11 2.61e-02
C12 N11 N12 1.69e-05
L12 N11 N12 7.98e-11
R12 N11 N12 8.62e-03
C13 N12 N13 7.93e-06
L13 N12 N13 7.99e-11
R13 N12 N13 9.23e-03
C14 N13 N14 6.73e-11
L14 N13 N14 1.77e-11
R14 N13 N14 2.25e+00
C15 N14 Port2 2.77e-12
L15 N14 Port2 9.97e-11
R15 N14 Port2 9.60e+00
.ENDS GRJ31CR71C475KE11

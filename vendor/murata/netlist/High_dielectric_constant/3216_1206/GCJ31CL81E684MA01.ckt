*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/6.80e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E684MA01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E684MA01 Port1 Port2
C01 Port1 N01 6.78e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 3.48e-10
R03 N02 N03 1.43e-02
C04 N03 N04 9.35e-05
R04 N03 N04 4.26e+01
C05 N04 N05 1.08e-04
R05 N04 N05 5.36e+00
C06 N05 N06 1.03e-04
R06 N05 N06 7.07e-01
C07 N06 N07 8.18e-05
R07 N06 N07 1.05e-01
C08 N07 N08 4.69e-05
R08 N07 N08 1.70e-02
L09 N08 N09 2.90e-11
R09 N08 N09 7.61e-02
L10 N09 N10 3.27e-10
R10 N09 N10 4.97e-02
C11 N10 N11 2.52e-06
L11 N10 N11 6.40e-11
R11 N10 N11 1.81e-02
C12 N11 N12 1.20e-06
L12 N11 N12 5.67e-11
R12 N11 N12 1.76e-02
C13 N12 N13 2.55e-11
L13 N12 N13 6.29e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 2.45e-12
L14 N13 Port2 1.49e-10
R14 N13 Port2 2.93e+01
.ENDS GCJ31CL81E684MA01

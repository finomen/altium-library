*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H225KA12
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H225KA12 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 1.11e-10
R03 N02 N03 1.01e-02
C04 N03 N04 3.07e-04
R04 N03 N04 1.31e+01
C05 N04 N05 2.88e-04
R05 N04 N05 1.92e+00
C06 N05 N06 2.49e-04
R06 N05 N06 3.15e-01
C07 N06 N07 2.18e-04
R07 N06 N07 4.88e-02
C08 N07 N08 1.54e-04
R08 N07 N08 8.72e-03
L09 N08 N09 2.42e-11
R09 N08 N09 1.56e-01
L10 N09 N10 4.72e-11
R10 N09 N10 3.95e-02
L11 N10 N11 3.40e-10
R11 N10 N11 3.55e-02
C12 N11 N12 5.56e-06
L12 N11 N12 1.05e-10
R12 N11 N12 1.20e-02
C13 N12 N13 2.64e-06
L13 N12 N13 9.12e-11
R13 N12 N13 1.27e-02
C14 N13 N14 4.02e-11
L14 N13 N14 3.84e-11
R14 N13 N14 5.87e+00
C15 N14 Port2 1.52e-12
L15 N14 Port2 3.33e-10
R15 N14 Port2 1.34e+02
.ENDS GCJ31CR71H225KA12

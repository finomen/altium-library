*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GC331CD72E683KX03
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331CD72E683KX03 Port1 Port2
C01 Port1 N01 6.84e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 5.30e-10
R03 N02 N03 1.26e-02
C04 N03 N04 2.37e-05
R04 N03 N04 9.57e+01
C05 N04 N05 3.16e-05
R05 N04 N05 1.37e+01
C06 N05 N06 2.88e-05
R06 N05 N06 3.00e+00
C07 N06 N07 2.64e-05
R07 N06 N07 6.21e-01
C08 N07 N08 2.29e-05
R08 N07 N08 1.33e-01
C09 N08 N09 1.74e-05
R09 N08 N09 2.79e-02
L10 N09 N10 4.75e-11
R10 N09 N10 6.82e-02
L11 N10 N11 4.11e-11
R11 N10 N11 2.73e-02
C12 N11 N12 1.44e-07
L12 N11 N12 4.77e-11
R12 N11 N12 6.52e-02
C13 N12 N13 7.45e-08
L13 N12 N13 2.52e-11
R13 N12 N13 3.14e-02
C14 N13 Port2 1.11e-11
L14 N13 Port2 1.50e-10
R14 N13 Port2 8.72e+00
.ENDS GC331CD72E683KX03

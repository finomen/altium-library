*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :LLL31MR71E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR71E104MA01 Port1 Port2
C01 Port1 N01 1.05e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 9.00e-12
R03 N02 N03 4.76e-03
C04 N03 N04 1.55e-05
R04 N03 N04 2.39e+02
C05 N04 N05 1.90e-05
R05 N04 N05 3.53e+01
C06 N05 N06 1.77e-05
R06 N05 N06 6.88e+00
C07 N06 N07 1.47e-05
R07 N06 N07 1.41e+00
C08 N07 N08 1.67e-05
R08 N07 N08 1.42e-01
C09 N08 N09 2.39e-05
R09 N08 N09 3.74e-02
C10 N09 N10 7.94e-06
R10 N09 N10 2.41e-02
C11 N10 N11 6.20e-06
R11 N10 N11 4.75e-03
L12 N11 N12 6.41e-11
R12 N11 N12 7.73e-02
C13 N12 N13 1.09e-07
L13 N12 N13 5.42e-11
R13 N12 N13 1.07e-01
C14 N13 N14 7.93e-08
L14 N13 N14 2.44e-11
R14 N13 N14 5.68e-02
C15 N14 N15 9.87e-12
L15 N14 N15 4.35e-11
R15 N14 N15 7.67e+00
C16 N15 Port2 6.63e-12
L16 N15 Port2 4.45e-11
R16 N15 Port2 1.00e+05
.ENDS LLL31MR71E104MA01

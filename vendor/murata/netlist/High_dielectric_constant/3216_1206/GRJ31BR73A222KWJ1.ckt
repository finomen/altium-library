*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A222KWJ1
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A222KWJ1 Port1 Port2
C01 Port1 N01 2.20e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-10
R03 N02 N03 2.37e-01
C04 N03 N04 2.91e-07
R04 N03 N04 7.57e+03
C05 N04 N05 3.68e-07
R05 N04 N05 1.23e+03
C06 N05 N06 3.26e-07
R06 N05 N06 2.72e+02
C07 N06 N07 3.10e-07
R07 N06 N07 5.61e+01
C08 N07 N08 2.63e-07
R08 N07 N08 1.24e+01
C09 N08 N09 2.03e-07
R09 N08 N09 2.74e+00
C10 N09 N10 1.80e-07
R10 N09 N10 6.46e-01
C11 N10 N11 4.68e-08
R11 N10 N11 2.81e-01
L12 N11 N12 3.63e-11
R12 N11 N12 8.23e-01
L13 N12 N13 5.77e-11
R13 N12 N13 4.28e-01
C14 N13 N14 3.25e-09
L14 N13 N14 1.89e-11
R14 N13 N14 1.55e-01
C15 N14 Port2 1.12e-11
L15 N14 Port2 2.28e-10
R15 N14 Port2 1.41e+01
.ENDS GRJ31BR73A222KWJ1

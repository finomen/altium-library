*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/25[V]
* Murata P/N :GRJ31CR71E106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71E106ME11 Port1 Port2
C01 Port1 N01 7.04e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.82e-11
R03 N02 N03 9.19e-03
C04 N03 N04 1.82e-04
R04 N03 N04 2.92e+01
C05 N04 N05 2.56e-04
R05 N04 N05 2.69e+00
C06 N05 N06 2.44e-04
R06 N05 N06 5.42e-01
C07 N06 N07 1.73e-04
R07 N06 N07 8.69e-02
C08 N07 N08 1.29e-04
R08 N07 N08 1.20e-02
C09 N08 N09 1.49e-04
R09 N08 N09 1.11e-03
L10 N09 N10 2.25e-11
R10 N09 N10 5.00e-02
L11 N10 N11 5.65e-11
R11 N10 N11 2.81e-02
L12 N11 N12 4.94e-10
R12 N11 N12 2.20e-02
C13 N12 N13 1.96e-05
L13 N12 N13 9.71e-11
R13 N12 N13 7.83e-03
C14 N13 N14 1.19e-05
L14 N13 N14 7.83e-11
R14 N13 N14 7.06e-03
C15 N14 N15 3.45e-11
L15 N14 N15 4.09e-11
R15 N14 N15 4.24e+00
C16 N15 Port2 1.01e-12
L16 N15 Port2 3.83e-10
R16 N15 Port2 1.48e+02
.ENDS GRJ31CR71E106ME11

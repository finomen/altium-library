*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GRJ31CR72A105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72A105KE11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 3.28e-10
R03 N02 N03 7.37e-03
C04 N03 N04 1.63e-04
R04 N03 N04 1.03e+01
C05 N04 N05 2.81e-04
R05 N04 N05 1.08e+00
C06 N05 N06 1.89e-04
R06 N05 N06 2.88e-01
C07 N06 N07 2.01e-04
R07 N06 N07 6.65e-02
C08 N07 N08 1.09e-04
R08 N07 N08 2.34e-02
C09 N08 N09 1.46e-04
R09 N08 N09 1.71e-03
L10 N09 N10 3.32e-10
R10 N09 N10 3.68e-02
L11 N10 N11 4.65e-11
R11 N10 N11 3.62e-02
C12 N11 N12 3.28e-06
L12 N11 N12 7.89e-11
R12 N11 N12 2.50e-02
C13 N12 N13 1.42e-06
L13 N12 N13 7.79e-11
R13 N12 N13 1.87e-02
C14 N13 N14 5.46e-10
L14 N13 N14 4.75e-11
R14 N13 N14 3.72e-01
C15 N14 Port2 3.16e-12
L15 N14 Port2 1.08e-10
R15 N14 Port2 8.97e+00
.ENDS GRJ31CR72A105KE11

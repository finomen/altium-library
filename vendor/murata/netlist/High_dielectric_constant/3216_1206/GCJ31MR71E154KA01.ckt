*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ31MR71E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71E154KA01 Port1 Port2
C01 Port1 N01 1.45e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.72e-10
R03 N02 N03 7.44e-02
C04 N03 N04 1.65e-05
R04 N03 N04 3.37e+02
C05 N04 N05 2.38e-05
R05 N04 N05 2.80e+01
C06 N05 N06 2.00e-05
R06 N05 N06 3.78e+00
C07 N06 N07 1.73e-05
R07 N06 N07 2.74e-01
C08 N07 N08 9.75e-05
R08 N07 N08 1.94e-01
C09 N08 N09 1.24e-05
R09 N08 N09 3.97e-02
L10 N09 N10 1.63e-10
R10 N09 N10 1.08e-01
L11 N10 N11 8.70e-12
R11 N10 N11 4.57e-02
C12 N11 N12 5.40e-07
L12 N11 N12 4.93e-11
R12 N11 N12 2.53e-02
C13 N12 N13 1.26e-07
L13 N12 N13 4.50e-11
R13 N12 N13 2.62e-02
C14 N13 N14 9.95e-12
L14 N13 N14 1.25e-10
R14 N13 N14 2.12e+01
C15 N14 Port2 1.76e-12
L15 N14 Port2 3.27e-10
R15 N14 Port2 6.35e+01
.ENDS GCJ31MR71E154KA01

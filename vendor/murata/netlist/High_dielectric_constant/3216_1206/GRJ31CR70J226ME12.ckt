*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRJ31CR70J226ME12
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR70J226ME12 Port1 Port2
C01 Port1 N01 1.58e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.19e-10
R03 N02 N03 7.95e-03
C04 N03 N04 3.60e-04
R04 N03 N04 1.54e+01
C05 N04 N05 4.76e-04
R05 N04 N05 9.76e-01
C06 N05 N06 4.58e-04
R06 N05 N06 1.05e-01
C07 N06 N07 2.96e-04
R07 N06 N07 1.30e-02
L08 N07 N08 1.55e-11
R08 N07 N08 5.62e-02
L09 N08 N09 7.83e-11
R09 N08 N09 3.82e-02
L10 N09 N10 5.31e-10
R10 N09 N10 1.50e-02
C11 N10 N11 5.33e-05
L11 N10 N11 9.61e-11
R11 N10 N11 3.97e-03
C12 N11 N12 3.22e-05
L12 N11 N12 7.85e-11
R12 N11 N12 4.48e-03
C13 N12 N13 3.46e-11
L13 N12 N13 3.84e-11
R13 N12 N13 4.85e+00
C14 N13 Port2 3.62e-12
L14 N13 Port2 1.05e-10
R14 N13 Port2 8.35e+00
.ENDS GRJ31CR70J226ME12

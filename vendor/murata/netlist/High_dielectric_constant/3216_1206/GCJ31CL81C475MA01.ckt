*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCJ31CL81C475MA01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81C475MA01 Port1 Port2
C01 Port1 N01 4.50e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.01e-10
R03 N02 N03 7.70e-03
C04 N03 N04 9.96e-04
R04 N03 N04 3.45e+00
C05 N04 N05 6.64e-04
R05 N04 N05 7.22e-01
C06 N05 N06 5.63e-04
R06 N05 N06 1.21e-01
C07 N06 N07 6.33e-04
R07 N06 N07 1.50e-02
C08 N07 N08 3.41e-04
R08 N07 N08 3.15e-03
L09 N08 N09 2.42e-11
R09 N08 N09 6.69e-02
L10 N09 N10 3.60e-10
R10 N09 N10 2.26e-02
L11 N10 N11 4.87e-11
R11 N10 N11 2.10e-02
C12 N11 N12 1.06e-05
L12 N11 N12 1.25e-10
R12 N11 N12 1.07e-02
C13 N12 N13 6.34e-06
L13 N12 N13 8.90e-11
R13 N12 N13 1.01e-02
C14 N13 N14 1.95e-11
L14 N13 N14 6.30e-11
R14 N13 N14 1.16e+01
C15 N14 Port2 1.51e-12
L15 N14 Port2 3.09e-10
R15 N14 Port2 1.16e+02
.ENDS GCJ31CL81C475MA01

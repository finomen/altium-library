*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J472KXJ1
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J472KXJ1 Port1 Port2
C01 Port1 N01 4.88e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.49e-10
R03 N02 N03 1.20e-01
C04 N03 N04 5.63e-07
R04 N03 N04 3.04e+03
C05 N04 N05 6.83e-07
R05 N04 N05 4.65e+02
C06 N05 N06 5.95e-07
R06 N05 N06 9.65e+01
C07 N06 N07 5.42e-07
R07 N06 N07 1.81e+01
C08 N07 N08 4.34e-07
R08 N07 N08 3.60e+00
C09 N08 N09 2.86e-07
R09 N08 N09 7.86e-01
C10 N09 N10 1.44e-07
R10 N09 N10 1.50e-01
L11 N10 N11 1.05e-10
R11 N10 N11 5.87e-01
L12 N11 N12 6.78e-11
R12 N11 N12 3.24e-01
C13 N12 N13 8.85e-08
L13 N12 N13 6.00e-12
R13 N12 N13 3.94e-02
C14 N13 N14 4.94e-09
L14 N13 N14 3.33e-11
R14 N13 N14 1.70e-01
C15 N14 Port2 1.37e-11
L15 N14 Port2 1.52e-10
R15 N14 Port2 8.73e+00
.ENDS GCJ31BR72J472KXJ1

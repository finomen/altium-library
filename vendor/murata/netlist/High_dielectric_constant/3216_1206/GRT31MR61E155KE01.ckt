*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.50e+00[uF]/25[V]
* Murata P/N :GRT31MR61E155KE01
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31MR61E155KE01 Port1 Port2
C01 Port1 N01 1.48e-06
R01 Port1 N01 3.33e+07
L02 N01 N02 7.00e-11
R03 N02 N03 5.78e-03
C04 N03 N04 3.06e-04
R04 N03 N04 6.33e+00
C05 N04 N05 2.23e-04
R05 N04 N05 1.50e+00
C06 N05 N06 1.82e-04
R06 N05 N06 2.73e-01
C07 N06 N07 1.60e-04
R07 N06 N07 4.05e-02
C08 N07 N08 1.29e-04
R08 N07 N08 6.68e-03
L09 N08 N09 3.50e-11
R09 N08 N09 3.65e-02
L10 N09 N10 2.36e-10
R10 N09 N10 3.40e-02
C11 N10 N11 6.45e-06
L11 N10 N11 4.82e-11
R11 N10 N11 9.03e-03
C12 N11 N12 1.82e-06
L12 N11 N12 7.33e-11
R12 N11 N12 1.45e-02
C13 N12 N13 1.97e-11
L13 N12 N13 1.02e-10
R13 N12 N13 9.04e+00
C14 N13 Port2 1.39e-12
L14 N13 Port2 3.78e-10
R14 N13 Port2 1.03e+02
.ENDS GRT31MR61E155KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/2.20e-02[uF]/450[V]
* Murata P/N :GC331BD72W223KX01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331BD72W223KX01 Port1 Port2
C01 Port1 N01 2.28e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 4.36e-10
R03 N02 N03 2.55e-02
C04 N03 N04 7.15e-06
R04 N03 N04 2.77e+02
C05 N04 N05 1.02e-05
R05 N04 N05 3.32e+01
C06 N05 N06 9.51e-06
R06 N05 N06 6.67e+00
C07 N06 N07 8.54e-06
R07 N06 N07 1.24e+00
C08 N07 N08 6.76e-06
R08 N07 N08 2.31e-01
C09 N08 N09 5.74e-06
R09 N08 N09 3.36e-02
L10 N09 N10 7.58e-11
R10 N09 N10 1.49e-01
L11 N10 N11 5.03e-11
R11 N10 N11 5.75e-02
C12 N11 N12 1.60e-07
L12 N11 N12 2.33e-11
R12 N11 N12 4.79e-02
C13 N12 N13 2.34e-08
L13 N12 N13 6.08e-11
R13 N12 N13 1.16e-01
C14 N13 N14 5.18e-10
L14 N13 N14 1.26e-11
R14 N13 N14 1.94e-01
C15 N14 Port2 9.35e-12
L15 N14 Port2 2.36e-10
R15 N14 Port2 2.37e+01
.ENDS GC331BD72W223KX01

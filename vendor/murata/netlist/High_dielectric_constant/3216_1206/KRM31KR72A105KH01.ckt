*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/100[V]
* Murata P/N :KRM31KR72A105KH01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31KR72A105KH01 Port1 Port2
C01 Port1 N01 9.80e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.45e-11
R03 N02 N03 1.15e-02
C04 N03 N04 1.73e-04
R04 N03 N04 8.01e-01
C05 N04 N05 1.23e-04
R05 N04 N05 1.26e-01
C06 N05 N06 1.25e-04
R06 N05 N06 1.21e-02
L07 N06 N07 4.35e-12
R07 N06 N07 1.16e-01
L08 N07 N08 3.18e-11
R08 N07 N08 7.30e-02
L09 N08 N09 4.43e-10
R09 N08 N09 6.37e-02
L10 N09 N10 3.09e-10
R10 N09 N10 5.51e-03
C11 N10 N11 2.67e-06
L11 N10 N11 1.03e-10
R11 N10 N11 2.15e-02
C12 N11 N12 1.51e-06
L12 N11 N12 6.89e-11
R12 N11 N12 2.16e-02
C13 N12 Port2 6.21e-13
L13 N12 Port2 1.43e-09
R13 N12 Port2 2.08e+03
.ENDS KRM31KR72A105KH01

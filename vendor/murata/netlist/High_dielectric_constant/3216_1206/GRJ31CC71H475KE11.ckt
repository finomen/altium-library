*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GRJ31CC71H475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC71H475KE11 Port1 Port2
C01 Port1 N01 4.46e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.18e-10
R03 N02 N03 9.00e-03
C04 N03 N04 5.78e-04
R04 N03 N04 2.82e+00
C05 N04 N05 8.15e-04
R05 N04 N05 2.18e-01
C06 N05 N06 7.94e-04
R06 N05 N06 3.42e-02
C07 N06 N07 5.24e-04
R07 N06 N07 4.51e-03
L08 N07 N08 2.93e-11
R08 N07 N08 1.01e-01
L09 N08 N09 5.69e-11
R09 N08 N09 3.16e-02
L10 N09 N10 4.60e-10
R10 N09 N10 2.75e-02
C11 N10 N11 1.25e-05
L11 N10 N11 1.20e-10
R11 N10 N11 1.07e-02
C12 N11 N12 7.94e-06
L12 N11 N12 8.64e-11
R12 N11 N12 1.02e-02
C13 N12 N13 2.79e-11
L13 N12 N13 4.21e-11
R13 N12 N13 3.91e+00
C14 N13 Port2 1.67e-12
L14 N13 Port2 2.38e-10
R14 N13 Port2 1.91e+02
.ENDS GRJ31CC71H475KE11

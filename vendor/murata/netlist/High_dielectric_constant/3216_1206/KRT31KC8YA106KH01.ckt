*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :KRT31KC8YA106KH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRT31KC8YA106KH01 Port1 Port2
C01 Port1 N01 7.54e-06
L02 N01 N02 3.92e-12
R03 N02 N03 4.86e-03
C04 N03 N04 4.35e-04
R04 N03 N04 1.00e+01
C05 N04 N05 5.03e-04
R05 N04 N05 1.15e+00
C06 N05 N06 4.94e-04
R06 N05 N06 1.35e-01
C07 N06 N07 4.65e-04
R07 N06 N07 1.58e-02
C08 N07 N08 7.17e-04
R08 N07 N08 1.39e-03
L09 N08 N09 1.75e-11
R09 N08 N09 1.11e-01
L10 N09 N10 9.24e-11
R10 N09 N10 3.98e-02
L11 N10 N11 7.61e-10
R11 N10 N11 2.29e-02
L12 N11 N12 1.10e-10
R12 N11 N12 6.31e-04
C13 N12 N13 5.67e-05
L13 N12 N13 4.21e-11
R13 N12 N13 2.83e-03
C14 N13 N14 2.06e-05
L14 N13 N14 4.85e-11
R14 N13 N14 3.39e-03
C15 N14 Port2 8.18e-13
L15 N14 Port2 1.40e-09
R15 N14 Port2 1.04e+03
.ENDS KRT31KC8YA106KH01

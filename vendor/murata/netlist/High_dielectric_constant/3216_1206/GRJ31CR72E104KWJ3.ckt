*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/250[V]
* Murata P/N :GRJ31CR72E104KWJ3
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR72E104KWJ3 Port1 Port2
C01 Port1 N01 1.03e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 5.52e-10
R03 N02 N03 2.55e-02
C04 N03 N04 9.18e-06
R04 N03 N04 1.97e+02
C05 N04 N05 1.09e-05
R05 N04 N05 3.76e+01
C06 N05 N06 8.89e-06
R06 N05 N06 8.44e+00
C07 N06 N07 8.11e-06
R07 N06 N07 1.57e+00
C08 N07 N08 7.41e-06
R08 N07 N08 3.33e-01
C09 N08 N09 6.62e-06
R09 N08 N09 4.24e-02
L10 N09 N10 3.05e-11
R10 N09 N10 7.27e-02
L11 N10 N11 1.54e-10
R11 N10 N11 7.06e-02
C12 N11 N12 7.24e-07
L12 N11 N12 2.84e-11
R12 N11 N12 2.06e-02
C13 N12 N13 1.08e-07
L13 N12 N13 7.45e-11
R13 N12 N13 4.45e-02
C14 N13 Port2 1.78e-11
L14 N13 Port2 9.36e-11
R14 N13 Port2 4.20e+00
.ENDS GRJ31CR72E104KWJ3

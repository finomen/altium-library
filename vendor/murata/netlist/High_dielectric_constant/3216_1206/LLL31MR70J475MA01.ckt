*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :LLL31MR70J475MA01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR70J475MA01 Port1 Port2
C01 Port1 N01 4.43e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 4.40e-11
R03 N02 N03 1.34e-03
C04 N03 N04 6.12e-04
R04 N03 N04 4.62e+00
C05 N04 N05 5.70e-04
R05 N04 N05 5.45e-01
C06 N05 N06 5.74e-04
R06 N05 N06 7.39e-02
C07 N06 N07 6.20e-04
R07 N06 N07 9.50e-03
C08 N07 N08 3.99e-04
R08 N07 N08 2.58e-03
L09 N08 N09 9.66e-12
R09 N08 N09 4.00e-02
L10 N09 N10 9.83e-11
R10 N09 N10 1.47e-02
C11 N10 N11 5.71e-06
L11 N10 N11 6.47e-11
R11 N10 N11 1.61e-02
C12 N11 N12 3.16e-06
L12 N11 N12 4.13e-11
R12 N11 N12 1.13e-02
C13 N12 Port2 7.70e-12
L13 N12 Port2 5.97e-11
R13 N12 Port2 1.04e+01
.ENDS LLL31MR70J475MA01

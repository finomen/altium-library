*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :LLL317R71H103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71H103MA01 Port1 Port2
C01 Port1 N01 1.04e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.64e-11
R03 N02 N03 2.30e-02
C04 N03 N04 1.10e-06
R04 N03 N04 2.69e+03
C05 N04 N05 1.83e-06
R05 N04 N05 2.19e+02
C06 N05 N06 2.01e-06
R06 N05 N06 3.63e+01
C07 N06 N07 1.69e-06
R07 N06 N07 8.70e+00
C08 N07 N08 1.23e-06
R08 N07 N08 1.48e+00
C09 N08 N09 8.02e-07
R09 N08 N09 2.47e-01
C10 N09 N10 5.16e-07
R10 N09 N10 4.41e-02
L11 N10 N11 1.97e-11
R11 N10 N11 1.43e-01
C12 N11 N12 1.36e-08
L12 N11 N12 1.75e-11
R12 N11 N12 1.20e-01
C13 N12 N13 3.40e-09
L13 N12 N13 1.80e-11
R13 N12 N13 9.57e-02
C14 N13 Port2 8.78e-12
L14 N13 Port2 5.60e-11
R14 N13 Port2 5.97e+00
.ENDS LLL317R71H103MA01

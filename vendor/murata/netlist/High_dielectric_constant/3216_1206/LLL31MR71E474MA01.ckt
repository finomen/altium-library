*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :LLL31MR71E474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR71E474MA01 Port1 Port2
C01 Port1 N01 4.57e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 3.85e-11
R03 N02 N03 2.67e-03
C04 N03 N04 5.46e-05
R04 N03 N04 7.28e+01
C05 N04 N05 1.04e-04
R05 N04 N05 6.95e+00
C06 N05 N06 6.12e-05
R06 N05 N06 2.15e+00
C07 N06 N07 5.91e-05
R07 N06 N07 3.49e-01
C08 N07 N08 5.14e-05
R08 N07 N08 4.38e-02
C09 N08 N09 5.16e-05
R09 N08 N09 6.29e-03
C10 N09 N10 3.74e-05
R10 N09 N10 1.64e-03
L11 N10 N11 8.19e-11
R11 N10 N11 3.51e-02
C12 N11 N12 5.93e-07
L12 N11 N12 5.01e-11
R12 N11 N12 5.88e-02
C13 N12 N13 3.87e-07
L13 N12 N13 2.67e-11
R13 N12 N13 3.26e-02
C14 N13 Port2 7.21e-12
L14 N13 Port2 7.78e-11
R14 N13 Port2 1.23e+01
.ENDS LLL31MR71E474MA01

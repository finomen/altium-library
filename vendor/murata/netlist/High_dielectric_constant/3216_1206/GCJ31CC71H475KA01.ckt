*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :GCJ31CC71H475KA01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC71H475KA01 Port1 Port2
C01 Port1 N01 4.33e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.09e-10
R03 N02 N03 7.00e-03
C04 N03 N04 9.48e-04
R04 N03 N04 3.02e+00
C05 N04 N05 7.51e-04
R05 N04 N05 5.53e-01
C06 N05 N06 6.59e-04
R06 N05 N06 7.47e-02
C07 N06 N07 5.10e-04
R07 N06 N07 8.14e-03
L08 N07 N08 3.12e-11
R08 N07 N08 9.21e-02
L09 N08 N09 5.92e-11
R09 N08 N09 2.55e-02
L10 N09 N10 4.38e-10
R10 N09 N10 2.38e-02
C11 N10 N11 1.31e-05
L11 N10 N11 1.12e-10
R11 N10 N11 1.07e-02
C12 N11 N12 7.67e-06
L12 N11 N12 8.45e-11
R12 N11 N12 1.03e-02
C13 N12 N13 2.35e-11
L13 N12 N13 4.95e-11
R13 N12 N13 5.20e+00
C14 N13 Port2 1.70e-12
L14 N13 Port2 2.48e-10
R14 N13 Port2 1.40e+02
.ENDS GCJ31CC71H475KA01

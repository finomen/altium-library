*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GRT31CC81H225KE01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81H225KE01 Port1 Port2
C01 Port1 N01 2.14e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 4.30e-11
R03 N02 N03 4.10e-03
C04 N03 N04 4.57e-04
R04 N03 N04 5.45e+00
C05 N04 N05 4.29e-04
R05 N04 N05 8.45e-01
C06 N05 N06 2.95e-04
R06 N05 N06 1.76e-01
C07 N06 N07 2.53e-04
R07 N06 N07 2.75e-02
C08 N07 N08 1.79e-04
R08 N07 N08 4.72e-03
L09 N08 N09 2.33e-11
R09 N08 N09 5.93e-02
L10 N09 N10 3.38e-10
R10 N09 N10 3.33e-02
L11 N10 N11 1.90e-11
R11 N10 N11 1.67e-02
C12 N11 N12 5.98e-06
L12 N11 N12 9.74e-11
R12 N11 N12 1.57e-02
C13 N12 N13 3.55e-06
L13 N12 N13 7.24e-11
R13 N12 N13 1.45e-02
C14 N13 N14 2.68e-11
L14 N13 N14 4.31e-11
R14 N13 N14 3.91e+00
C15 N14 Port2 1.06e-12
L15 N14 Port2 3.23e-10
R15 N14 Port2 1.50e+02
.ENDS GRT31CC81H225KE01

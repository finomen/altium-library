*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A106ME11 Port1 Port2
C01 Port1 N01 9.75e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.39e-10
R03 N02 N03 1.02e-02
C04 N03 N04 8.30e-04
R04 N03 N04 6.39e+00
C05 N04 N05 1.16e-03
R05 N04 N05 4.22e-01
C06 N05 N06 1.03e-03
R06 N05 N06 5.43e-02
C07 N06 N07 1.93e-03
R07 N06 N07 5.77e-03
C08 N07 N08 6.88e-04
R08 N07 N08 1.37e-03
L09 N08 N09 2.36e-11
R09 N08 N09 4.68e-02
L10 N09 N10 7.02e-11
R10 N09 N10 2.93e-02
L11 N10 N11 5.65e-10
R11 N10 N11 1.79e-02
C12 N11 N12 3.36e-05
L12 N11 N12 1.05e-10
R12 N11 N12 5.30e-03
C13 N12 N13 2.19e-05
L13 N12 N13 7.31e-11
R13 N12 N13 5.22e-03
C14 N13 N14 2.36e-11
L14 N13 N14 3.45e-11
R14 N13 N14 3.52e+00
C15 N14 Port2 2.86e-12
L15 N14 Port2 1.04e-10
R15 N14 Port2 1.55e+01
.ENDS GRJ31CR71A106ME11

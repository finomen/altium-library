*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GRT31CR61E475KE01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61E475KE01 Port1 Port2
C01 Port1 N01 4.60e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.17e-11
R03 N02 N03 3.16e-03
C04 N03 N04 6.60e-04
R04 N03 N04 6.56e+00
C05 N04 N05 9.25e-04
R05 N04 N05 1.02e+00
C06 N05 N06 7.02e-04
R06 N05 N06 2.83e-01
C07 N06 N07 5.70e-04
R07 N06 N07 5.64e-02
C08 N07 N08 7.82e-04
R08 N07 N08 7.08e-03
C09 N08 N09 4.82e-04
R09 N08 N09 2.69e-03
L10 N09 N10 1.27e-11
R10 N09 N10 3.91e-02
L11 N10 N11 4.14e-11
R11 N10 N11 2.89e-02
L12 N11 N12 3.68e-10
R12 N11 N12 2.19e-02
C13 N12 N13 1.56e-05
L13 N12 N13 8.52e-11
R13 N12 N13 8.46e-03
C14 N13 N14 6.66e-06
L14 N13 N14 9.05e-11
R14 N13 N14 8.92e-03
C15 N14 N15 1.88e-11
L15 N14 N15 6.52e-11
R15 N14 N15 4.47e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.79e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CR61E475KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :LLL317R71E473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71E473MA01 Port1 Port2
C01 Port1 N01 4.81e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.64e-11
R03 N02 N03 1.26e-02
C04 N03 N04 6.94e-06
R04 N03 N04 4.26e+02
C05 N04 N05 1.01e-05
R05 N04 N05 5.75e+01
C06 N05 N06 8.25e-06
R06 N05 N06 1.48e+01
C07 N06 N07 6.88e-06
R07 N06 N07 2.24e+00
C08 N07 N08 6.39e-06
R08 N07 N08 3.64e-01
C09 N08 N09 4.56e-06
R09 N08 N09 6.21e-02
C10 N09 N10 2.88e-06
R10 N09 N10 1.37e-02
L11 N10 N11 3.26e-11
R11 N10 N11 1.62e-01
C12 N11 N12 6.81e-08
L12 N11 N12 1.87e-11
R12 N11 N12 4.65e-02
C13 N12 N13 1.98e-08
L13 N12 N13 1.69e-11
R13 N12 N13 3.44e-02
C14 N13 Port2 8.19e-12
L14 N13 Port2 5.80e-11
R14 N13 Port2 5.90e+00
.ENDS LLL317R71E473MA01

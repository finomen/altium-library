*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-02[uF]/250[V]
* Murata P/N :GRJ31BR72E683KWJ1
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72E683KWJ1 Port1 Port2
C01 Port1 N01 6.83e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 4.87e-10
R03 N02 N03 3.60e-02
C04 N03 N04 5.61e-06
R04 N03 N04 2.96e+02
C05 N04 N05 6.73e-06
R05 N04 N05 5.57e+01
C06 N05 N06 5.50e-06
R06 N05 N06 1.23e+01
C07 N06 N07 5.17e-06
R07 N06 N07 2.21e+00
C08 N07 N08 4.29e-06
R08 N07 N08 4.76e-01
C09 N08 N09 4.12e-06
R09 N08 N09 5.63e-02
L10 N09 N10 6.26e-11
R10 N09 N10 1.31e-01
L11 N10 N11 1.08e-10
R11 N10 N11 5.32e-02
C12 N11 N12 1.28e-07
L12 N11 N12 3.77e-11
R12 N11 N12 3.10e-02
C13 N12 N13 2.03e-07
L13 N12 N13 8.42e-12
R13 N12 N13 9.71e-03
C14 N13 Port2 1.37e-11
L14 N13 Port2 1.35e-10
R14 N13 Port2 6.90e+00
.ENDS GRJ31BR72E683KWJ1

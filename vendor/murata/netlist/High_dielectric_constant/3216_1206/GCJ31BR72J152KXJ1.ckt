*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J152KXJ1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J152KXJ1 Port1 Port2
C01 Port1 N01 1.56e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-10
R03 N02 N03 3.29e-01
C04 N03 N04 2.22e-07
R04 N03 N04 9.00e+03
C05 N04 N05 2.57e-07
R05 N04 N05 1.69e+03
C06 N05 N06 2.28e-07
R06 N05 N06 3.62e+02
C07 N06 N07 2.15e-07
R07 N06 N07 7.35e+01
C08 N07 N08 1.80e-07
R08 N07 N08 1.59e+01
C09 N08 N09 1.32e-07
R09 N08 N09 3.58e+00
C10 N09 N10 7.50e-08
R10 N09 N10 8.72e-01
C11 N10 N11 2.79e-08
R11 N10 N11 1.95e-01
L12 N11 N12 5.45e-11
R12 N11 N12 8.78e-01
L13 N12 N13 3.34e-11
R13 N12 N13 6.83e-01
C14 N13 N14 5.36e-10
L14 N13 N14 2.85e-11
R14 N13 N14 3.66e-01
C15 N14 Port2 7.35e-12
L15 N14 Port2 3.40e-10
R15 N14 Port2 1.70e+01
.ENDS GCJ31BR72J152KXJ1

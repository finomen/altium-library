*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/25[V]
* Murata P/N :GCJ31CR71E475MA12
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71E475MA12 Port1 Port2
C01 Port1 N01 4.56e-06
R01 Port1 N01 1.06e+08
L02 N01 N02 1.09e-10
R03 N02 N03 8.23e-03
C04 N03 N04 5.52e-04
R04 N03 N04 8.77e+00
C05 N04 N05 7.11e-04
R05 N04 N05 8.27e-01
C06 N05 N06 5.82e-04
R06 N05 N06 1.45e-01
C07 N06 N07 6.20e-04
R07 N06 N07 1.90e-02
C08 N07 N08 4.74e-04
R08 N07 N08 3.65e-03
L09 N08 N09 1.53e-11
R09 N08 N09 6.97e-02
L10 N09 N10 4.89e-11
R10 N09 N10 3.21e-02
L11 N10 N11 3.66e-10
R11 N10 N11 2.44e-02
C12 N11 N12 1.14e-05
L12 N11 N12 1.18e-10
R12 N11 N12 1.05e-02
C13 N12 N13 6.15e-06
L13 N12 N13 9.32e-11
R13 N12 N13 1.02e-02
C14 N13 N14 1.70e-11
L14 N13 N14 7.11e-11
R14 N13 N14 8.68e+00
C15 N14 Port2 1.56e-12
L15 N14 Port2 3.00e-10
R15 N14 Port2 1.22e+02
.ENDS GCJ31CR71E475MA12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+01[uF]/10[V]
* Murata P/N :GRT31CR61A476KE13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61A476KE13 Port1 Port2
C01 Port1 N01 3.33e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 9.41e-11
R03 N02 N03 2.21e-03
C04 N03 N04 7.47e-04
R04 N03 N04 6.78e+00
C05 N04 N05 8.74e-04
R05 N04 N05 5.74e-01
C06 N05 N06 7.85e-04
R06 N05 N06 7.16e-02
C07 N06 N07 6.85e-04
R07 N06 N07 9.06e-03
C08 N07 N08 1.60e-03
R08 N07 N08 6.07e-04
L09 N08 N09 1.82e-11
R09 N08 N09 6.03e-02
L10 N09 N10 7.51e-11
R10 N09 N10 2.71e-02
L11 N10 N11 4.49e-10
R11 N10 N11 1.18e-02
C12 N11 N12 8.35e-05
L12 N11 N12 1.04e-10
R12 N11 N12 2.56e-03
C13 N12 N13 3.43e-05
L13 N12 N13 1.26e-10
R13 N12 N13 3.56e-03
C14 N13 N14 1.43e-11
L14 N13 N14 7.94e-11
R14 N13 N14 9.56e+00
C15 N14 Port2 1.80e-12
L15 N14 Port2 2.28e-10
R15 N14 Port2 1.66e+02
.ENDS GRT31CR61A476KE13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/1000[V]
* Murata P/N :GCJ31CR73A103KXJ3
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR73A103KXJ3 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.69e-10
R03 N02 N03 7.21e-02
C04 N03 N04 1.13e-06
R04 N03 N04 1.62e+03
C05 N04 N05 1.35e-06
R05 N04 N05 2.94e+02
C06 N05 N06 1.15e-06
R06 N05 N06 6.40e+01
C07 N06 N07 1.08e-06
R07 N06 N07 1.22e+01
C08 N07 N08 8.39e-07
R08 N07 N08 2.50e+00
C09 N08 N09 7.46e-07
R09 N08 N09 4.49e-01
C10 N09 N10 4.61e-07
R10 N09 N10 7.45e-02
L11 N10 N11 1.06e-10
R11 N10 N11 2.38e-01
L12 N11 N12 2.76e-11
R12 N11 N12 1.46e-01
C13 N12 N13 5.81e-08
L13 N12 N13 3.10e-11
R13 N12 N13 1.10e-01
C14 N13 N14 1.03e-08
L14 N13 N14 6.92e-11
R14 N13 N14 1.58e-01
C15 N14 Port2 3.47e-11
L15 N14 Port2 5.89e-11
R15 N14 Port2 2.58e+00
.ENDS GCJ31CR73A103KXJ3

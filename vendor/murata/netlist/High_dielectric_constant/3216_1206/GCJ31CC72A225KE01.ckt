*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7S(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :GCJ31CC72A225KE01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CC72A225KE01 Port1 Port2
C01 Port1 N01 2.08e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.69e-10
R03 N02 N03 6.58e-03
C04 N03 N04 2.78e-04
R04 N03 N04 1.91e+01
C05 N04 N05 2.16e-04
R05 N04 N05 3.13e+00
C06 N05 N06 1.70e-04
R06 N05 N06 5.30e-01
C07 N06 N07 1.87e-04
R07 N06 N07 5.22e-02
C08 N07 N08 1.20e-04
R08 N07 N08 9.04e-03
L09 N08 N09 4.37e-11
R09 N08 N09 7.05e-02
L10 N09 N10 3.56e-10
R10 N09 N10 3.33e-02
C11 N10 N11 5.95e-06
L11 N10 N11 9.34e-11
R11 N10 N11 1.28e-02
C12 N11 N12 2.57e-06
L12 N11 N12 8.89e-11
R12 N11 N12 1.21e-02
C13 N12 Port2 2.28e-12
L13 N12 Port2 2.16e-10
R13 N12 Port2 2.42e+01
.ENDS GCJ31CC72A225KE01

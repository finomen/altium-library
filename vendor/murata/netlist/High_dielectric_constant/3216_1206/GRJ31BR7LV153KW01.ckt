*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GRJ31BR7LV153KW01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR7LV153KW01 Port1 Port2
C01 Port1 N01 1.58e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.50e-10
R03 N02 N03 9.86e-02
C04 N03 N04 1.18e-06
R04 N03 N04 2.47e+03
C05 N04 N05 1.63e-06
R05 N04 N05 3.08e+02
C06 N05 N06 1.50e-06
R06 N05 N06 6.71e+01
C07 N06 N07 1.40e-06
R07 N06 N07 1.42e+01
C08 N07 N08 1.16e-06
R08 N07 N08 2.79e+00
C09 N08 N09 1.02e-06
R09 N08 N09 5.54e-01
C10 N09 N10 7.55e-07
R10 N09 N10 1.29e-01
L11 N10 N11 7.74e-11
R11 N10 N11 2.30e-01
L12 N11 N12 2.51e-11
R12 N11 N12 3.07e-02
C13 N12 N13 8.51e-08
L13 N12 N13 6.00e-12
R13 N12 N13 1.05e-02
C14 N13 Port2 5.81e-12
L14 N13 Port2 3.77e-10
R14 N13 Port2 2.53e+01
.ENDS GRJ31BR7LV153KW01

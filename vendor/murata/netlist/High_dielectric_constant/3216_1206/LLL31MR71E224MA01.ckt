*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :LLL31MR71E224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR71E224MA01 Port1 Port2
C01 Port1 N01 2.17e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.20e-11
R03 N02 N03 4.54e-03
C04 N03 N04 2.58e-05
R04 N03 N04 1.43e+02
C05 N04 N05 4.82e-05
R05 N04 N05 1.50e+01
C06 N05 N06 3.76e-05
R06 N05 N06 3.77e+00
C07 N06 N07 2.83e-05
R07 N06 N07 6.70e-01
C08 N07 N08 2.50e-05
R08 N07 N08 7.33e-02
C09 N08 N09 2.52e-05
R09 N08 N09 1.21e-02
C10 N09 N10 1.14e-05
R10 N09 N10 4.44e-03
L11 N10 N11 5.52e-11
R11 N10 N11 5.67e-02
C12 N11 N12 2.63e-07
L12 N11 N12 5.07e-11
R12 N11 N12 5.36e-02
C13 N12 N13 1.37e-07
L13 N12 N13 2.96e-11
R13 N12 N13 3.13e-02
C14 N13 N14 2.15e-10
L14 N13 N14 2.51e-11
R14 N13 N14 2.96e-01
C15 N14 Port2 6.86e-12
L15 N14 Port2 7.09e-11
R15 N14 Port2 7.53e+00
.ENDS LLL31MR71E224MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H224KA01 Port1 Port2
C01 Port1 N01 2.14e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 4.33e-11
R03 N02 N03 6.35e-02
C04 N03 N04 2.87e-05
R04 N03 N04 1.39e+02
C05 N04 N05 3.72e-05
R05 N04 N05 1.55e+01
C06 N05 N06 6.37e-05
R06 N05 N06 1.32e+00
C07 N06 N07 4.48e-05
R07 N06 N07 6.19e-01
C08 N07 N08 3.89e-05
R08 N07 N08 1.55e-01
C09 N08 N09 2.16e-05
R09 N08 N09 5.86e-02
C10 N09 N10 2.38e-05
R10 N09 N10 1.52e-02
L11 N10 N11 2.91e-10
R11 N10 N11 8.33e-02
L12 N11 N12 2.67e-11
R12 N11 N12 8.14e-02
C13 N12 N13 1.16e-06
L13 N12 N13 3.35e-11
R13 N12 N13 1.97e-02
C14 N13 N14 4.82e-07
L14 N13 N14 3.21e-11
R14 N13 N14 2.15e-02
C15 N14 N15 1.03e-11
L15 N14 N15 8.15e-11
R15 N14 N15 1.27e+01
C16 N15 Port2 8.79e-13
L16 N15 Port2 4.34e-10
R16 N15 Port2 8.57e+01
.ENDS GCJ31MR71H224KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31MR71H105KE01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H105KE01 Port1 Port2
C01 Port1 N01 9.69e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 3.22e-10
R03 N02 N03 3.11e-02
C04 N03 N04 7.86e-05
R04 N03 N04 2.43e+01
C05 N04 N05 2.35e-04
R05 N04 N05 2.29e+00
C06 N05 N06 1.15e-04
R06 N05 N06 5.65e-01
C07 N06 N07 1.15e-04
R07 N06 N07 5.89e-02
C08 N07 N08 9.69e-05
R08 N07 N08 1.67e-02
L09 N08 N09 3.87e-11
R09 N08 N09 7.92e-02
L10 N09 N10 2.94e-10
R10 N09 N10 4.83e-02
C11 N10 N11 3.14e-06
L11 N10 N11 6.46e-11
R11 N10 N11 1.19e-02
C12 N11 N12 1.45e-06
L12 N11 N12 5.52e-11
R12 N11 N12 1.43e-02
C13 N12 N13 8.71e-12
L13 N12 N13 1.06e-10
R13 N12 N13 8.01e+00
C14 N13 Port2 3.91e-12
L14 N13 Port2 1.01e-10
R14 N13 Port2 2.33e+01
.ENDS GRJ31MR71H105KE01

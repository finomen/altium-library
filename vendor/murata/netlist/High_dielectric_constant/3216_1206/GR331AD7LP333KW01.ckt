*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/3.30e-02[uF]/450[V]
* Murata P/N :GR331AD7LP333KW01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR331AD7LP333KW01 Port1 Port2
C01 Port1 N01 3.23e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 5.04e-10
R03 N02 N03 1.93e-02
C04 N03 N04 9.73e-06
R04 N03 N04 2.26e+02
C05 N04 N05 1.37e-05
R05 N04 N05 2.72e+01
C06 N05 N06 1.25e-05
R06 N05 N06 5.90e+00
C07 N06 N07 1.10e-05
R07 N06 N07 1.20e+00
C08 N07 N08 9.08e-06
R08 N07 N08 2.33e-01
C09 N08 N09 7.61e-06
R09 N08 N09 4.07e-02
L10 N09 N10 8.90e-11
R10 N09 N10 1.57e-01
L11 N10 N11 4.21e-11
R11 N10 N11 4.53e-02
C12 N11 N12 1.86e-07
L12 N11 N12 2.71e-11
R12 N11 N12 5.13e-02
C13 N12 N13 3.06e-08
L13 N12 N13 6.19e-11
R13 N12 N13 1.03e-01
C14 N13 Port2 1.55e-11
L14 N13 Port2 1.12e-10
R14 N13 Port2 6.53e+00
.ENDS GR331AD7LP333KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-01[uF]/50[V]
* Murata P/N :GRJ31MR71H474KE01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71H474KE01 Port1 Port2
C01 Port1 N01 4.42e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 4.95e-11
R03 N02 N03 3.94e-02
C04 N03 N04 2.97e-05
R04 N03 N04 7.23e-02
C05 N04 N05 6.38e-05
R05 N04 N05 2.58e-03
L06 N05 N06 3.06e-11
R06 N05 N06 7.71e-02
L07 N06 N07 2.60e-10
R07 N06 N07 6.20e-02
C08 N07 N08 1.41e-06
L08 N07 N08 6.08e-11
R08 N07 N08 2.06e-02
C09 N08 N09 8.32e-07
L09 N08 N09 4.17e-11
R09 N08 N09 2.18e-02
C10 N09 N10 9.54e-12
L10 N09 N10 1.09e-10
R10 N09 N10 1.12e+01
C11 N10 Port2 1.43e-12
L11 N10 Port2 3.30e-10
R11 N10 Port2 1.45e+02
.ENDS GRJ31MR71H474KE01

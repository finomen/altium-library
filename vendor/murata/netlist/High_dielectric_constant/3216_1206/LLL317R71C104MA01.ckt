*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :LLL317R71C104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71C104MA01 Port1 Port2
C01 Port1 N01 9.93e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.01e-11
R03 N02 N03 1.10e-02
C04 N03 N04 1.20e-05
R04 N03 N04 3.31e+02
C05 N04 N05 1.74e-05
R05 N04 N05 4.16e+01
C06 N05 N06 1.56e-05
R06 N05 N06 6.75e+00
C07 N06 N07 1.38e-05
R07 N06 N07 1.29e+00
C08 N07 N08 1.12e-05
R08 N07 N08 2.01e-01
C09 N08 N09 1.00e-05
R09 N08 N09 3.07e-02
C10 N09 N10 7.80e-06
R10 N09 N10 8.03e-03
L11 N10 N11 3.41e-11
R11 N10 N11 5.76e-02
C12 N11 N12 1.01e-07
L12 N11 N12 1.76e-11
R12 N11 N12 1.55e-02
C13 N12 N13 1.09e-11
L13 N12 N13 9.24e-11
R13 N12 N13 1.17e+01
C14 N13 Port2 6.65e-12
L14 N13 Port2 5.32e-11
R14 N13 Port2 7.28e+00
.ENDS LLL317R71C104MA01

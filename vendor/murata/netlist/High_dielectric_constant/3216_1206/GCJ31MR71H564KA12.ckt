*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/5.60e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H564KA12
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H564KA12 Port1 Port2
C01 Port1 N01 5.60e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.82e-10
R03 N02 N03 3.12e-02
C04 N03 N04 6.76e-05
R04 N03 N04 5.89e+01
C05 N04 N05 8.76e-05
R05 N04 N05 6.61e+00
C06 N05 N06 8.30e-05
R06 N05 N06 8.13e-01
C07 N06 N07 6.99e-05
R07 N06 N07 1.07e-01
C08 N07 N08 3.99e-05
R08 N07 N08 2.43e-02
L09 N08 N09 3.62e-11
R09 N08 N09 1.33e-01
L10 N09 N10 2.62e-10
R10 N09 N10 5.71e-02
C11 N10 N11 2.54e-06
L11 N10 N11 4.51e-11
R11 N10 N11 1.27e-02
C12 N11 N12 7.95e-07
L12 N11 N12 5.80e-11
R12 N11 N12 1.82e-02
C13 N12 N13 1.60e-11
L13 N12 N13 6.70e-11
R13 N12 N13 7.11e+00
C14 N13 Port2 1.39e-12
L14 N13 Port2 2.62e-10
R14 N13 Port2 1.09e+02
.ENDS GCJ31MR71H564KA12

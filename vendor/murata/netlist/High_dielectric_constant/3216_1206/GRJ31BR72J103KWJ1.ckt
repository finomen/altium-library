*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GRJ31BR72J103KWJ1
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J103KWJ1 Port1 Port2
C01 Port1 N01 1.04e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.75e-10
R03 N02 N03 7.16e-02
C04 N03 N04 1.18e-06
R04 N03 N04 1.60e+03
C05 N04 N05 1.42e-06
R05 N04 N05 2.86e+02
C06 N05 N06 1.21e-06
R06 N05 N06 6.33e+01
C07 N06 N07 1.12e-06
R07 N06 N07 1.25e+01
C08 N07 N08 9.10e-07
R08 N07 N08 2.56e+00
C09 N08 N09 8.20e-07
R09 N08 N09 4.94e-01
C10 N09 N10 4.25e-07
R10 N09 N10 9.65e-02
L11 N10 N11 6.64e-11
R11 N10 N11 3.55e-01
L12 N11 N12 7.99e-11
R12 N11 N12 2.26e-01
C13 N12 N13 7.63e-08
L13 N12 N13 1.75e-11
R13 N12 N13 6.11e-02
C14 N13 N14 1.13e-08
L14 N13 N14 4.45e-11
R14 N13 N14 1.23e-01
C15 N14 Port2 1.44e-11
L15 N14 Port2 1.17e-10
R15 N14 Port2 5.85e+00
.ENDS GRJ31BR72J103KWJ1

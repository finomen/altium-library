*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/16[V]
* Murata P/N :GCJ31CR71C106MA15
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71C106MA15 Port1 Port2
C01 Port1 N01 6.63e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.71e-10
R03 N02 N03 8.21e-03
C04 N03 N04 1.68e-04
R04 N03 N04 2.56e+01
C05 N04 N05 2.39e-04
R05 N04 N05 2.23e+00
C06 N05 N06 2.16e-04
R06 N05 N06 3.88e-01
C07 N06 N07 1.85e-04
R07 N06 N07 5.87e-02
C08 N07 N08 1.27e-04
R08 N07 N08 1.05e-02
L09 N08 N09 2.12e-11
R09 N08 N09 7.31e-02
L10 N09 N10 4.63e-11
R10 N09 N10 2.42e-02
L11 N10 N11 3.23e-10
R11 N10 N11 2.09e-02
C12 N11 N12 1.75e-05
L12 N11 N12 1.04e-10
R12 N11 N12 7.43e-03
C13 N12 N13 7.20e-06
L13 N12 N13 1.10e-10
R13 N12 N13 9.04e-03
C14 N13 N14 1.58e-11
L14 N13 N14 7.51e-11
R14 N13 N14 1.61e+01
C15 N14 Port2 1.73e-12
L15 N14 Port2 2.85e-10
R15 N14 Port2 1.19e+02
.ENDS GCJ31CR71C106MA15

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :LLL317R71E223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71E223MA01 Port1 Port2
C01 Port1 N01 2.12e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-11
R03 N02 N03 2.27e-02
C04 N03 N04 2.30e-06
R04 N03 N04 1.56e+03
C05 N04 N05 7.79e-06
R05 N04 N05 8.01e+01
C06 N05 N06 3.14e-06
R06 N05 N06 4.50e+01
C07 N06 N07 3.33e-06
R07 N06 N07 4.71e+00
C08 N07 N08 2.98e-06
R08 N07 N08 7.19e-01
C09 N08 N09 3.41e-06
R09 N08 N09 1.38e-01
C10 N09 N10 1.83e-06
R10 N09 N10 4.81e-02
C11 N10 N11 2.15e-06
R11 N10 N11 1.15e-02
L12 N11 N12 2.00e-11
R12 N11 N12 1.60e-01
C13 N12 N13 3.16e-08
L13 N12 N13 1.29e-11
R13 N12 N13 3.57e-02
C14 N13 N14 1.19e-08
L14 N13 N14 8.71e-12
R14 N13 N14 3.34e-02
C15 N14 N15 8.74e-12
L15 N14 N15 9.23e-11
R15 N14 N15 9.99e+00
C16 N15 Port2 1.81e-11
L16 N15 Port2 2.16e-11
R16 N15 Port2 2.76e+00
.ENDS LLL317R71E223MA01

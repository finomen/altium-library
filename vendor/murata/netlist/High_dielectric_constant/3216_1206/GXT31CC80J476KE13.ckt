*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :GXT31CC80J476KE13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CC80J476KE13 Port1 Port2
C01 Port1 N01 3.36e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 1.25e-10
R03 N02 N03 2.14e-03
C04 N03 N04 1.03e-03
R04 N03 N04 4.70e+00
C05 N04 N05 1.03e-03
R05 N04 N05 8.15e-01
C06 N05 N06 9.48e-04
R06 N05 N06 1.21e-01
C07 N06 N07 8.75e-04
R07 N06 N07 1.83e-02
C08 N07 N08 7.21e-04
R08 N07 N08 3.36e-03
L09 N08 N09 2.55e-11
R09 N08 N09 4.94e-02
L10 N09 N10 7.49e-11
R10 N09 N10 2.09e-02
L11 N10 N11 4.80e-10
R11 N10 N11 1.11e-02
C12 N11 N12 1.49e-04
L12 N11 N12 7.83e-11
R12 N11 N12 2.18e-03
C13 N12 N13 3.96e-05
L13 N12 N13 1.43e-10
R13 N12 N13 3.55e-03
C14 N13 N14 2.08e-11
L14 N13 N14 5.74e-11
R14 N13 N14 6.65e+00
C15 N14 Port2 1.83e-12
L15 N14 Port2 2.18e-10
R15 N14 Port2 6.94e+01
.ENDS GXT31CC80J476KE13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :LLL315R71C224MA11
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71C224MA11 Port1 Port2
C01 Port1 N01 2.17e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 4.44e-11
R03 N02 N03 4.40e-03
C04 N03 N04 2.38e-05
R04 N03 N04 1.67e+02
C05 N04 N05 4.04e-05
R05 N04 N05 1.79e+01
C06 N05 N06 2.76e-05
R06 N05 N06 4.10e+00
C07 N06 N07 2.95e-05
R07 N06 N07 4.82e-01
C08 N07 N08 2.75e-05
R08 N07 N08 9.29e-02
C09 N08 N09 2.84e-05
R09 N08 N09 1.18e-02
C10 N09 N10 2.13e-05
R10 N09 N10 6.46e-03
C11 N10 N11 9.72e-06
R11 N10 N11 1.91e-03
L12 N11 N12 2.61e-11
R12 N11 N12 4.31e-02
C13 N12 N13 2.90e-07
L13 N12 N13 1.93e-11
R13 N12 N13 2.34e-02
C14 N13 N14 6.31e-08
L14 N13 N14 2.21e-11
R14 N13 N14 1.88e-02
C15 N14 Port2 9.16e-12
L15 N14 Port2 4.59e-11
R15 N14 Port2 5.37e+00
.ENDS LLL315R71C224MA11

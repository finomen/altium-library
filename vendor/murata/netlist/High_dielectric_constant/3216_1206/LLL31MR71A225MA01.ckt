*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e+00[uF]/10[V]
* Murata P/N :LLL31MR71A225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR71A225MA01 Port1 Port2
C01 Port1 N01 2.11e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 3.69e-11
R03 N02 N03 1.66e-03
C04 N03 N04 3.56e-04
R04 N03 N04 8.46e+00
C05 N04 N05 3.91e-04
R05 N04 N05 1.13e+00
C06 N05 N06 2.32e-04
R06 N05 N06 4.14e-01
C07 N06 N07 2.46e-04
R07 N06 N07 6.10e-02
C08 N07 N08 2.89e-04
R08 N07 N08 8.87e-03
C09 N08 N09 1.94e-04
R09 N08 N09 3.55e-03
L10 N09 N10 7.76e-12
R10 N09 N10 3.55e-02
L11 N10 N11 1.13e-10
R11 N10 N11 2.09e-02
C12 N11 N12 2.44e-06
L12 N11 N12 7.21e-11
R12 N11 N12 2.65e-02
C13 N12 N13 2.18e-06
L13 N12 N13 2.97e-11
R13 N12 N13 1.58e-02
C14 N13 Port2 7.46e-12
L14 N13 Port2 4.48e-11
R14 N13 Port2 8.79e+00
.ENDS LLL31MR71A225MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT31CR61C475ME01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61C475ME01 Port1 Port2
C01 Port1 N01 4.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.94e-11
R03 N02 N03 3.32e-03
C04 N03 N04 8.72e-04
R04 N03 N04 4.09e+00
C05 N04 N05 8.78e-04
R05 N04 N05 5.96e-01
C06 N05 N06 7.82e-04
R06 N05 N06 1.23e-01
C07 N06 N07 7.74e-04
R07 N06 N07 2.87e-02
C08 N07 N08 6.67e-04
R08 N07 N08 7.56e-03
C09 N08 N09 6.54e-04
R09 N08 N09 1.57e-03
L10 N09 N10 1.29e-11
R10 N09 N10 8.11e-02
L11 N10 N11 5.34e-11
R11 N10 N11 3.72e-02
L12 N11 N12 3.81e-10
R12 N11 N12 2.11e-02
C13 N12 N13 1.38e-05
L13 N12 N13 8.91e-11
R13 N12 N13 8.26e-03
C14 N13 N14 7.91e-06
L14 N13 N14 7.19e-11
R14 N13 N14 7.74e-03
C15 N14 N15 1.46e-11
L15 N14 N15 7.86e-11
R15 N14 N15 5.44e+00
C16 N15 Port2 9.95e-13
L16 N15 Port2 3.52e-10
R16 N15 Port2 1.60e+02
.ENDS GRT31CR61C475ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GC331AD7LQ153KX18
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331AD7LQ153KX18 Port1 Port2
C01 Port1 N01 1.54e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.77e-10
R03 N02 N03 3.27e-02
C04 N03 N04 4.36e-06
R04 N03 N04 9.35e+02
C05 N04 N05 7.06e-06
R05 N04 N05 8.26e+01
C06 N05 N06 7.19e-06
R06 N05 N06 1.70e+01
C07 N06 N07 6.95e-06
R07 N06 N07 3.77e+00
C08 N07 N08 6.10e-06
R08 N07 N08 8.62e-01
C09 N08 N09 5.00e-06
R09 N08 N09 1.96e-01
C10 N09 N10 4.29e-06
R10 N09 N10 3.81e-02
L11 N10 N11 9.38e-11
R11 N10 N11 3.00e-01
L12 N11 N12 2.58e-11
R12 N11 N12 4.57e-02
C13 N12 N13 1.08e-07
L13 N12 N13 1.77e-11
R13 N12 N13 4.74e-02
C14 N13 N14 1.38e-08
L14 N13 N14 5.15e-11
R14 N13 N14 1.16e-01
C15 N14 Port2 1.09e-11
L15 N14 Port2 1.34e-10
R15 N14 Port2 8.41e+00
.ENDS GC331AD7LQ153KX18

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.50e+00[uF]/50[V]
* Murata P/N :GRT31CR61H155KE01
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CR61H155KE01 Port1 Port2
C01 Port1 N01 1.44e-06
R01 Port1 N01 3.33e+07
L02 N01 N02 9.25e-11
R03 N02 N03 6.85e-03
C04 N03 N04 3.41e-04
R04 N03 N04 1.11e+01
C05 N04 N05 2.91e-04
R05 N04 N05 2.32e+00
C06 N05 N06 1.85e-04
R06 N05 N06 5.24e-01
C07 N06 N07 1.70e-04
R07 N06 N07 7.03e-02
C08 N07 N08 1.10e-04
R08 N07 N08 1.22e-02
L09 N08 N09 1.90e-10
R09 N08 N09 3.79e-02
L10 N09 N10 2.36e-11
R10 N09 N10 2.63e-02
C11 N10 N11 4.99e-06
L11 N10 N11 6.38e-11
R11 N10 N11 9.98e-03
C12 N11 N12 1.28e-06
L12 N11 N12 1.00e-10
R12 N11 N12 1.55e-02
C13 N12 N13 1.95e-11
L13 N12 N13 1.31e-10
R13 N12 N13 8.93e+00
C14 N13 Port2 1.71e-12
L14 N13 Port2 4.17e-10
R14 N13 Port2 6.77e+01
.ENDS GRT31CR61H155KE01

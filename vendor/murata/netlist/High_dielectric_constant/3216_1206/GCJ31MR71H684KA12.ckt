*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H684KA12
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H684KA12 Port1 Port2
C01 Port1 N01 6.77e-07
R01 Port1 N01 7.35e+08
L02 N01 N02 1.58e-10
R03 N02 N03 1.68e-02
C04 N03 N04 8.49e-05
R04 N03 N04 1.47e+01
C05 N04 N05 1.01e-04
R05 N04 N05 1.62e+00
C06 N05 N06 1.00e-04
R06 N05 N06 2.45e-01
C07 N06 N07 8.14e-05
R07 N06 N07 4.45e-02
C08 N07 N08 5.68e-05
R08 N07 N08 9.66e-03
L09 N08 N09 2.28e-10
R09 N08 N09 4.68e-02
L10 N09 N10 2.89e-11
R10 N09 N10 4.48e-02
C11 N10 N11 3.44e-06
L11 N10 N11 3.53e-11
R11 N10 N11 8.94e-03
C12 N11 N12 9.26e-07
L12 N11 N12 4.91e-11
R12 N11 N12 1.43e-02
C13 N12 N13 1.54e-11
L13 N12 N13 1.22e-10
R13 N12 N13 1.43e+01
C14 N13 Port2 1.81e-12
L14 N13 Port2 3.82e-10
R14 N13 Port2 7.30e+01
.ENDS GCJ31MR71H684KA12

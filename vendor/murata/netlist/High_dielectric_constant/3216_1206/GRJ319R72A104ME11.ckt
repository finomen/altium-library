*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ319R72A104ME11
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ319R72A104ME11 Port1 Port2
C01 Port1 N01 9.90e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 3.46e-10
R03 N02 N03 6.20e-02
C04 N03 N04 1.36e-05
R04 N03 N04 2.52e+02
C05 N04 N05 1.86e-05
R05 N04 N05 3.11e+01
C06 N05 N06 1.82e-05
R06 N05 N06 4.00e+00
C07 N06 N07 1.53e-05
R07 N06 N07 5.04e-01
C08 N07 N08 5.54e-05
R08 N07 N08 4.00e-01
C09 N08 N09 1.35e-05
R09 N08 N09 9.84e-02
C10 N09 N10 8.42e-06
R10 N09 N10 3.63e-02
L11 N10 N11 1.50e-10
R11 N10 N11 1.22e-01
C12 N11 N12 3.38e-07
L12 N11 N12 2.98e-11
R12 N11 N12 1.56e-02
C13 N12 N13 1.12e-07
L13 N12 N13 3.12e-11
R13 N12 N13 2.32e-02
C14 N13 N14 2.02e-11
L14 N13 N14 5.79e-11
R14 N13 N14 9.96e+00
C15 N14 Port2 1.45e-12
L15 N14 Port2 2.44e-10
R15 N14 Port2 2.50e+01
.ENDS GRJ319R72A104ME11

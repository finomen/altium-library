*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+00[uF]/50[V]
* Murata P/N :GRJ31CR71H105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71H105KE11 Port1 Port2
C01 Port1 N01 1.01e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 1.29e-10
R03 N02 N03 1.22e-02
C04 N03 N04 1.21e-04
R04 N03 N04 1.68e+01
C05 N04 N05 1.29e-04
R05 N04 N05 1.34e+00
C06 N05 N06 1.15e-04
R06 N05 N06 1.54e-01
C07 N06 N07 7.87e-05
R07 N06 N07 2.27e-02
C08 N07 N08 1.58e-04
R08 N07 N08 1.64e-03
L09 N08 N09 4.15e-11
R09 N08 N09 7.01e-02
L10 N09 N10 3.48e-10
R10 N09 N10 4.72e-02
C11 N10 N11 3.33e-06
L11 N10 N11 7.68e-11
R11 N10 N11 1.75e-02
C12 N11 N12 1.48e-06
L12 N11 N12 7.40e-11
R12 N11 N12 1.90e-02
C13 N12 N13 2.16e-11
L13 N12 N13 6.98e-11
R13 N12 N13 5.93e+00
C14 N13 Port2 1.30e-12
L14 N13 Port2 3.44e-10
R14 N13 Port2 1.07e+02
.ENDS GRJ31CR71H105KE11

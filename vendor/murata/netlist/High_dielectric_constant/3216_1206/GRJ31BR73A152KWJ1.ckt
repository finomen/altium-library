*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A152KWJ1
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A152KWJ1 Port1 Port2
C01 Port1 N01 1.58e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.81e-10
R03 N02 N03 2.59e-01
C04 N03 N04 2.24e-07
R04 N03 N04 9.26e+03
C05 N04 N05 2.59e-07
R05 N04 N05 1.71e+03
C06 N05 N06 2.33e-07
R06 N05 N06 3.63e+02
C07 N06 N07 2.21e-07
R07 N06 N07 7.49e+01
C08 N07 N08 1.87e-07
R08 N07 N08 1.65e+01
C09 N08 N09 1.43e-07
R09 N08 N09 3.76e+00
C10 N09 N10 8.73e-08
R10 N09 N10 9.56e-01
C11 N10 N11 3.17e-08
R11 N10 N11 2.59e-01
L12 N11 N12 8.05e-11
R12 N11 N12 1.19e+00
L13 N12 N13 6.10e-11
R13 N12 N13 8.35e-01
C14 N13 N14 1.82e-09
L14 N13 N14 1.92e-11
R14 N13 N14 2.70e-01
C15 N14 Port2 9.34e-12
L15 N14 Port2 2.37e-10
R15 N14 Port2 1.50e+01
.ENDS GRJ31BR73A152KWJ1

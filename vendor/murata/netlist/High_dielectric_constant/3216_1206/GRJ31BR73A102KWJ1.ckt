*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A102KWJ1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A102KWJ1 Port1 Port2
C01 Port1 N01 1.07e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.09e-10
R03 N02 N03 3.59e-01
C04 N03 N04 1.46e-07
R04 N03 N04 1.47e+04
C05 N04 N05 1.94e-07
R05 N04 N05 2.03e+03
C06 N05 N06 1.66e-07
R06 N05 N06 4.65e+02
C07 N06 N07 1.58e-07
R07 N06 N07 9.17e+01
C08 N07 N08 1.34e-07
R08 N07 N08 1.96e+01
C09 N08 N09 9.89e-08
R09 N08 N09 4.41e+00
C10 N09 N10 7.10e-08
R10 N09 N10 9.25e-01
C11 N10 N11 1.61e-08
R11 N10 N11 3.86e-01
L12 N11 N12 7.48e-11
R12 N11 N12 1.45e+00
L13 N12 N13 6.91e-11
R13 N12 N13 1.01e+00
C14 N13 N14 9.70e-10
L14 N13 N14 3.23e-11
R14 N13 N14 4.09e-01
C15 N14 Port2 1.37e-11
L15 N14 Port2 1.55e-10
R15 N14 Port2 9.32e+00
.ENDS GRJ31BR73A102KWJ1

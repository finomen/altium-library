*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e-04[uF]/1000[V]
* Murata P/N :GRJ31BR73A471KWJ1
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A471KWJ1 Port1 Port2
C01 Port1 N01 5.02e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 4.64e-10
R03 N02 N03 4.99e-01
C04 N03 N04 4.62e-08
R04 N03 N04 7.11e+04
C05 N04 N05 6.45e-08
R05 N04 N05 5.30e+03
C06 N05 N06 6.48e-08
R06 N05 N06 1.02e+03
C07 N06 N07 6.14e-08
R07 N06 N07 2.04e+02
C08 N07 N08 4.94e-08
R08 N07 N08 4.17e+01
C09 N08 N09 3.38e-08
R09 N08 N09 8.85e+00
C10 N09 N10 1.70e-08
R10 N09 N10 2.11e+00
C11 N10 N11 7.34e-09
R11 N10 N11 5.57e-01
C12 N11 N12 1.84e-10
L12 N11 N12 3.84e-11
R12 N11 N12 1.53e+00
C13 N12 Port2 5.90e-12
L13 N12 Port2 5.26e-10
R13 N12 Port2 3.15e+01
.ENDS GRJ31BR73A471KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :LLL317R71E104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71E104MA01 Port1 Port2
C01 Port1 N01 1.04e-07
R01 Port1 N01 5.00e+09
L02 N01 N02 4.12e-11
R03 N02 N03 6.51e-03
C04 N03 N04 1.26e-05
R04 N03 N04 2.94e+02
C05 N04 N05 1.99e-05
R05 N04 N05 3.38e+01
C06 N05 N06 1.46e-05
R06 N05 N06 7.22e+00
C07 N06 N07 1.34e-05
R07 N06 N07 1.09e+00
C08 N07 N08 1.37e-05
R08 N07 N08 1.16e-01
C09 N08 N09 1.12e-05
R09 N08 N09 2.79e-02
C10 N09 N10 6.17e-06
R10 N09 N10 9.23e-03
L11 N10 N11 7.67e-12
R11 N10 N11 8.37e-02
L12 N11 N12 4.05e-11
R12 N11 N12 6.72e-02
C13 N12 N13 1.22e-07
L13 N12 N13 2.99e-11
R13 N12 N13 4.57e-02
C14 N13 N14 6.41e-08
L14 N13 N14 1.58e-11
R14 N13 N14 2.96e-02
C15 N14 Port2 1.05e-11
L15 N14 Port2 4.99e-11
R15 N14 Port2 5.49e+00
.ENDS LLL317R71E104MA01

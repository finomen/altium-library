*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/1.00e+00[uF]/100[V]
* Murata P/N :GCJ31CL8EL105KA07
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8EL105KA07 Port1 Port2
C01 Port1 N01 9.60e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 1.04e-10
R03 N02 N03 7.90e-03
C04 N03 N04 2.79e-04
R04 N03 N04 6.86e+00
C05 N04 N05 1.53e-04
R05 N04 N05 2.27e+00
C06 N05 N06 1.36e-04
R06 N05 N06 3.69e-01
C07 N06 N07 1.24e-04
R07 N06 N07 5.30e-02
C08 N07 N08 9.26e-05
R08 N07 N08 9.18e-03
L09 N08 N09 2.60e-10
R09 N08 N09 4.02e-02
L10 N09 N10 2.63e-11
R10 N09 N10 2.00e-02
C11 N10 N11 2.15e-06
L11 N10 N11 1.14e-10
R11 N10 N11 2.74e-02
C12 N11 N12 1.22e-06
L12 N11 N12 8.21e-11
R12 N11 N12 2.34e-02
C13 N12 N13 4.26e-10
L13 N12 N13 5.83e-11
R13 N12 N13 3.84e-01
C14 N13 Port2 1.50e-12
L14 N13 Port2 3.41e-10
R14 N13 Port2 1.05e+02
.ENDS GCJ31CL8EL105KA07

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GCJ31CL8ED226KE07
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL8ED226KE07 Port1 Port2
C01 Port1 N01 1.54e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.08e-10
R03 N02 N03 4.20e-03
C04 N03 N04 3.97e-04
R04 N03 N04 1.31e+01
C05 N04 N05 5.69e-04
R05 N04 N05 1.10e+00
C06 N05 N06 4.86e-04
R06 N05 N06 1.76e-01
C07 N06 N07 4.67e-04
R07 N06 N07 2.25e-02
C08 N07 N08 3.04e-04
R08 N07 N08 4.26e-03
L09 N08 N09 2.61e-11
R09 N08 N09 6.94e-02
L10 N09 N10 7.70e-11
R10 N09 N10 2.53e-02
L11 N10 N11 4.56e-10
R11 N10 N11 1.44e-02
C12 N11 N12 3.35e-05
L12 N11 N12 1.25e-10
R12 N11 N12 4.82e-03
C13 N12 N13 2.08e-05
L13 N12 N13 9.01e-11
R13 N12 N13 4.72e-03
C14 N13 N14 1.90e-11
L14 N13 N14 5.34e-11
R14 N13 N14 1.12e+01
C15 N14 Port2 1.45e-12
L15 N14 Port2 2.95e-10
R15 N14 Port2 1.20e+02
.ENDS GCJ31CL8ED226KE07

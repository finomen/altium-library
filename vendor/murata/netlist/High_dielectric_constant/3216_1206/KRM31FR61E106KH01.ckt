*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :KRM31FR61E106KH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31FR61E106KH01 Port1 Port2
C01 Port1 N01 6.82e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.05e-11
R03 N02 N03 7.87e-03
C04 N03 N04 2.09e-04
R04 N03 N04 5.38e+00
C05 N04 N05 2.20e-04
R05 N04 N05 4.91e-01
C06 N05 N06 2.50e-04
R06 N05 N06 6.44e-02
C07 N06 N07 1.61e-04
R07 N06 N07 1.93e-02
L08 N07 N08 8.39e-12
R08 N07 N08 1.60e-01
L09 N08 N09 1.35e-10
R09 N08 N09 7.94e-02
L10 N09 N10 5.12e-10
R10 N09 N10 1.89e-02
L11 N10 N11 7.31e-11
R11 N10 N11 1.25e-03
C12 N11 Port2 7.12e-13
L12 N11 Port2 1.20e-09
R12 N11 Port2 4.18e+02
.ENDS KRM31FR61E106KH01

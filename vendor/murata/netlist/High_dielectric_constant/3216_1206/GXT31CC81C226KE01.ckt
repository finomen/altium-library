*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GXT31CC81C226KE01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT31CC81C226KE01 Port1 Port2
C01 Port1 N01 1.72e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.95e-11
R03 N02 N03 2.47e-03
C04 N03 N04 7.52e-04
R04 N03 N04 4.17e+00
C05 N04 N05 1.17e-03
R05 N04 N05 3.20e-01
C06 N05 N06 1.06e-03
R06 N05 N06 5.99e-02
C07 N06 N07 2.39e-03
R07 N06 N07 6.36e-03
C08 N07 N08 7.89e-04
R08 N07 N08 5.04e-03
L09 N08 N09 1.66e-11
R09 N08 N09 6.68e-02
L10 N09 N10 6.88e-11
R10 N09 N10 2.58e-02
L11 N10 N11 4.15e-10
R11 N10 N11 1.31e-02
C12 N11 N12 6.03e-05
L12 N11 N12 9.24e-11
R12 N11 N12 3.66e-03
C13 N12 N13 2.37e-05
L13 N12 N13 1.07e-10
R13 N12 N13 4.59e-03
C14 N13 N14 2.46e-11
L14 N13 N14 6.16e-11
R14 N13 N14 6.15e+00
C15 N14 Port2 1.22e-12
L15 N14 Port2 3.88e-10
R15 N14 Port2 1.25e+02
.ENDS GXT31CC81C226KE01

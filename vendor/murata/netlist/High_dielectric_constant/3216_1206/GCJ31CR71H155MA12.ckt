*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.50e+00[uF]/50[V]
* Murata P/N :GCJ31CR71H155MA12
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71H155MA12 Port1 Port2
C01 Port1 N01 1.47e-06
R01 Port1 N01 3.33e+08
L02 N01 N02 1.73e-10
R03 N02 N03 5.97e-03
C04 N03 N04 2.38e-04
R04 N03 N04 1.37e+01
C05 N04 N05 2.28e-04
R05 N04 N05 2.58e+00
C06 N05 N06 1.76e-04
R06 N05 N06 4.80e-01
C07 N06 N07 1.61e-04
R07 N06 N07 6.59e-02
C08 N07 N08 1.15e-04
R08 N07 N08 1.07e-02
L09 N08 N09 2.70e-10
R09 N08 N09 3.69e-02
L10 N09 N10 3.39e-11
R10 N09 N10 3.06e-02
C11 N10 N11 4.46e-06
L11 N10 N11 7.92e-11
R11 N10 N11 1.43e-02
C12 N11 N12 1.73e-06
L12 N11 N12 8.22e-11
R12 N11 N12 1.68e-02
C13 N12 N13 8.37e-12
L13 N12 N13 1.78e-10
R13 N12 N13 2.73e+01
C14 N13 Port2 2.41e-12
L14 N13 Port2 3.24e-10
R14 N13 Port2 6.26e+01
.ENDS GCJ31CR71H155MA12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/35[V]
* Murata P/N :GRJ31CC8YA106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CC8YA106KE01 Port1 Port2
C01 Port1 N01 6.54e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 9.31e-11
R03 N02 N03 4.41e-03
C04 N03 N04 1.76e-04
R04 N03 N04 5.69e+00
C05 N04 N05 2.05e-04
R05 N04 N05 4.90e-01
C06 N05 N06 1.91e-04
R06 N05 N06 6.67e-02
C07 N06 N07 1.20e-04
R07 N06 N07 1.04e-02
L08 N07 N08 1.54e-11
R08 N07 N08 7.26e-02
L09 N08 N09 6.79e-11
R09 N08 N09 4.01e-02
L10 N09 N10 4.95e-10
R10 N09 N10 2.38e-02
C11 N10 N11 3.43e-05
L11 N10 N11 5.79e-11
R11 N10 N11 6.34e-03
C12 N11 N12 9.60e-06
L12 N11 N12 9.76e-11
R12 N11 N12 7.06e-03
C13 N12 N13 3.63e-11
L13 N12 N13 3.84e-11
R13 N12 N13 7.10e+00
C14 N13 Port2 1.47e-12
L14 N13 Port2 3.52e-10
R14 N13 Port2 1.19e+02
.ENDS GRJ31CC8YA106KE01

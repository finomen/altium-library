*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.50e+00[uF]/50[V]
* Murata P/N :GRT31CC81H155KE01
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81H155KE01 Port1 Port2
C01 Port1 N01 1.42e-06
R01 Port1 N01 3.33e+07
L02 N01 N02 1.25e-10
R03 N02 N03 6.17e-03
C04 N03 N04 1.88e-04
R04 N03 N04 2.81e+00
C05 N04 N05 1.84e-04
R05 N04 N05 2.99e-01
C06 N05 N06 1.50e-04
R06 N05 N06 4.72e-02
C07 N06 N07 1.20e-04
R07 N06 N07 7.88e-03
L08 N07 N08 2.74e-10
R08 N07 N08 3.18e-02
L09 N08 N09 3.24e-11
R09 N08 N09 2.48e-02
C10 N09 N10 6.81e-06
L10 N09 N10 4.77e-11
R10 N09 N10 8.94e-03
C11 N10 N11 2.14e-06
L11 N10 N11 6.27e-11
R11 N10 N11 1.08e-02
C12 N11 N12 2.73e-11
L12 N11 N12 9.75e-11
R12 N11 N12 7.22e+00
C13 N12 Port2 1.56e-12
L13 N12 Port2 4.12e-10
R13 N12 Port2 6.31e+01
.ENDS GRT31CC81H155KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/1.00e-02[uF]/630[V]
* Murata P/N :GR331BD72J103KW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR331BD72J103KW01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.90e-10
R03 N02 N03 2.54e-02
C04 N03 N04 3.07e-06
R04 N03 N04 9.55e+02
C05 N04 N05 4.56e-06
R05 N04 N05 7.78e+01
C06 N05 N06 4.50e-06
R06 N05 N06 1.30e+01
C07 N06 N07 4.21e-06
R07 N06 N07 2.25e+00
C08 N07 N08 3.38e-06
R08 N07 N08 4.17e-01
C09 N08 N09 2.32e-06
R09 N08 N09 6.98e-02
L10 N09 N10 1.34e-10
R10 N09 N10 2.74e-01
L11 N10 N11 9.79e-11
R11 N10 N11 2.06e-02
C12 N11 N12 7.23e-08
L12 N11 N12 2.07e-11
R12 N11 N12 8.87e-02
C13 N12 N13 1.70e-08
L13 N12 N13 3.57e-11
R13 N12 N13 1.41e-01
C14 N13 Port2 1.02e-11
L14 N13 Port2 2.04e-10
R14 N13 Port2 1.66e+01
.ENDS GR331BD72J103KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/25[V]
* Murata P/N :GRJ31MR71E225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31MR71E225ME11 Port1 Port2
C01 Port1 N01 2.22e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.43e-10
R03 N02 N03 1.86e-02
C04 N03 N04 2.36e-04
R04 N03 N04 1.11e+01
C05 N04 N05 4.14e-04
R05 N04 N05 1.30e+00
C06 N05 N06 3.14e-04
R06 N05 N06 2.86e-01
C07 N06 N07 2.32e-04
R07 N06 N07 5.76e-02
C08 N07 N08 2.07e-04
R08 N07 N08 8.18e-03
L09 N08 N09 5.71e-11
R09 N08 N09 7.48e-02
L10 N09 N10 3.60e-10
R10 N09 N10 3.35e-02
C11 N10 N11 6.41e-06
L11 N10 N11 8.29e-11
R11 N10 N11 8.29e-03
C12 N11 N12 4.10e-06
L12 N11 N12 5.91e-11
R12 N11 N12 1.05e-02
C13 N12 N13 1.58e-11
L13 N12 N13 7.52e-11
R13 N12 N13 5.09e+00
C14 N13 Port2 1.83e-12
L14 N13 Port2 2.35e-10
R14 N13 Port2 1.02e+02
.ENDS GRJ31MR71E225ME11

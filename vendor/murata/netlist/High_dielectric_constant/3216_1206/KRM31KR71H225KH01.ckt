*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :KRM31KR71H225KH01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31KR71H225KH01 Port1 Port2
C01 Port1 N01 2.11e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 2.26e-11
R03 N02 N03 5.42e-03
C04 N03 N04 2.57e-04
R04 N03 N04 1.35e-01
C05 N04 N05 2.14e-04
R05 N04 N05 1.37e-02
C06 N05 N06 4.99e-05
R06 N05 N06 2.86e-03
L07 N06 N07 5.29e-11
R07 N06 N07 8.35e-02
L08 N07 N08 4.55e-10
R08 N07 N08 5.17e-02
L09 N08 N09 7.72e-10
R09 N08 N09 8.76e-03
C10 N09 N10 3.56e-04
L10 N09 N10 1.20e-03
R10 N09 N10 6.93e-01
C11 N10 N11 5.95e-06
L11 N10 N11 1.02e-10
R11 N10 N11 1.12e-02
C12 N11 N12 2.13e-06
L12 N11 N12 1.20e-10
R12 N11 N12 1.48e-02
C13 N12 Port2 6.71e-13
L13 N12 Port2 1.42e-09
R13 N12 Port2 7.86e+02
.ENDS KRM31KR71H225KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e-02[uF]/16[V]
* Murata P/N :LLL315R71C223MA11
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71C223MA11 Port1 Port2
C01 Port1 N01 2.40e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.32e-11
R03 N02 N03 1.61e-02
C04 N03 N04 2.80e-06
R04 N03 N04 1.14e+03
C05 N04 N05 5.15e-06
R05 N04 N05 1.30e+02
C06 N05 N06 3.64e-06
R06 N05 N06 3.28e+01
C07 N06 N07 3.19e-06
R07 N06 N07 5.44e+00
C08 N07 N08 3.20e-06
R08 N07 N08 7.55e-01
C09 N08 N09 2.07e-06
R09 N08 N09 1.49e-01
C10 N09 N10 1.26e-06
R10 N09 N10 3.34e-02
L11 N10 N11 1.88e-11
R11 N10 N11 8.87e-02
C12 N11 N12 3.10e-08
L12 N11 N12 1.30e-11
R12 N11 N12 5.25e-02
C13 N12 N13 9.12e-09
L13 N12 N13 1.06e-11
R13 N12 N13 4.19e-02
C14 N13 Port2 9.27e-12
L14 N13 Port2 4.67e-11
R14 N13 Port2 5.61e+00
.ENDS LLL315R71C223MA11

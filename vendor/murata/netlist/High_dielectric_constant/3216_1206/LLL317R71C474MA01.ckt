*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :LLL317R71C474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71C474MA01 Port1 Port2
C01 Port1 N01 4.75e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 3.63e-11
R03 N02 N03 3.22e-03
C04 N03 N04 5.53e-05
R04 N03 N04 7.20e+01
C05 N04 N05 7.80e-05
R05 N04 N05 8.27e+00
C06 N05 N06 6.80e-05
R06 N05 N06 1.44e+00
C07 N06 N07 7.32e-05
R07 N06 N07 2.61e-01
C08 N07 N08 5.64e-05
R08 N07 N08 4.24e-02
C09 N08 N09 6.18e-05
R09 N08 N09 6.46e-03
C10 N09 N10 4.83e-05
R10 N09 N10 2.35e-03
L11 N10 N11 2.19e-11
R11 N10 N11 1.20e-01
L12 N11 N12 4.58e-11
R12 N11 N12 3.03e-02
C13 N12 N13 6.98e-07
L13 N12 N13 3.42e-11
R13 N12 N13 3.08e-02
C14 N13 N14 3.43e-07
L14 N13 N14 2.23e-11
R14 N13 N14 2.00e-02
C15 N14 Port2 1.06e-11
L15 N14 Port2 4.48e-11
R15 N14 Port2 6.35e+00
.ENDS LLL317R71C474MA01

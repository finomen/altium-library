*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/50[V]
* Murata P/N :GGM31CR71H225KA55
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGM31CR71H225KA55 Port1 Port2
C01 Port1 N01 2.23e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 4.09e-11
R03 N02 N03 4.29e-03
C04 N03 N04 3.31e-04
R04 N03 N04 1.16e+01
C05 N04 N05 4.37e-04
R05 N04 N05 1.46e+00
C06 N05 N06 2.76e-04
R06 N05 N06 3.49e-01
C07 N06 N07 2.54e-04
R07 N06 N07 5.01e-02
C08 N07 N08 3.48e-04
R08 N07 N08 6.21e-03
C09 N08 N09 2.43e-04
R09 N08 N09 2.18e-03
L10 N09 N10 4.28e-11
R10 N09 N10 6.72e-02
L11 N10 N11 3.21e-10
R11 N10 N11 3.86e-02
C12 N11 N12 5.72e-06
L12 N11 N12 1.02e-10
R12 N11 N12 1.64e-02
C13 N12 N13 2.41e-06
L13 N12 N13 1.07e-10
R13 N12 N13 1.61e-02
C14 N13 N14 2.14e-11
L14 N13 N14 5.72e-11
R14 N13 N14 3.92e+00
C15 N14 Port2 1.50e-12
L15 N14 Port2 3.05e-10
R15 N14 Port2 1.18e+02
.ENDS GGM31CR71H225KA55

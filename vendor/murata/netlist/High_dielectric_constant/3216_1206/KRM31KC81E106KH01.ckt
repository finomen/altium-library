*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/1.00e+01[uF]/25[V]
* Murata P/N :KRM31KC81E106KH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31KC81E106KH01 Port1 Port2
C01 Port1 N01 7.70e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.02e-10
R03 N02 N03 1.17e-02
C04 N03 N04 3.71e-04
R04 N03 N04 2.81e+00
C05 N04 N05 3.90e-04
R05 N04 N05 2.40e-01
C06 N05 N06 3.53e-04
R06 N05 N06 2.05e-02
L07 N06 N07 1.83e-10
R07 N06 N07 6.06e-02
L08 N07 N08 4.85e-12
R08 N07 N08 4.39e-02
L09 N08 N09 1.29e-09
R09 N08 N09 3.24e-02
C10 N09 N10 1.22e-11
L10 N09 N10 1.38e-10
R10 N09 N10 3.10e+01
C11 N10 N11 1.23e-12
L11 N10 N11 1.02e-09
R11 N10 N11 1.59e+02
C12 N11 Port2 8.78e-12
L12 N11 Port2 7.50e-11
R12 N11 Port2 2.86e+01
.ENDS KRM31KC81E106KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e-01[uF]/25[V]
* Murata P/N :LLL315R71E104MA11
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71E104MA11 Port1 Port2
C01 Port1 N01 9.80e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 3.66e-11
R03 N02 N03 6.65e-03
C04 N03 N04 1.13e-05
R04 N03 N04 3.51e+02
C05 N04 N05 1.84e-05
R05 N04 N05 3.94e+01
C06 N05 N06 1.29e-05
R06 N05 N06 9.45e+00
C07 N06 N07 1.26e-05
R07 N06 N07 1.22e+00
C08 N07 N08 1.39e-05
R08 N07 N08 1.48e-01
C09 N08 N09 1.01e-05
R09 N08 N09 4.07e-02
C10 N09 N10 1.35e-05
R10 N09 N10 8.77e-03
C11 N10 N11 6.75e-06
R11 N10 N11 4.93e-03
L12 N11 N12 3.18e-11
R12 N11 N12 5.92e-02
C13 N12 N13 1.05e-07
L13 N12 N13 2.35e-11
R13 N12 N13 3.42e-02
C14 N13 N14 6.13e-08
L14 N13 N14 1.08e-11
R14 N13 N14 2.25e-02
C15 N14 Port2 8.96e-12
L15 N14 Port2 5.40e-11
R15 N14 Port2 8.18e+00
.ENDS LLL315R71E104MA11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e-02[uF]/250[V]
* Murata P/N :GRJ31BR72E223KWJ1
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72E223KWJ1 Port1 Port2
C01 Port1 N01 2.26e-08
R01 Port1 N01 4.55e+09
L02 N01 N02 4.91e-10
R03 N02 N03 6.72e-02
C04 N03 N04 2.60e-06
R04 N03 N04 7.42e+02
C05 N04 N05 2.77e-06
R05 N04 N05 1.86e+02
C06 N05 N06 2.41e-06
R06 N05 N06 4.06e+01
C07 N06 N07 2.23e-06
R07 N06 N07 8.51e+00
C08 N07 N08 1.92e-06
R08 N07 N08 1.78e+00
C09 N08 N09 1.49e-06
R09 N08 N09 4.23e-01
C10 N09 N10 1.19e-06
R10 N09 N10 6.22e-02
L11 N10 N11 9.42e-11
R11 N10 N11 3.48e-01
L12 N11 N12 5.47e-11
R12 N11 N12 6.42e-02
C13 N12 N13 4.67e-08
L13 N12 N13 2.48e-11
R13 N12 N13 3.69e-02
C14 N13 N14 1.10e-07
L14 N13 N14 5.38e-12
R14 N13 N14 1.61e-02
C15 N14 Port2 8.80e-12
L15 N14 Port2 2.32e-10
R15 N14 Port2 2.37e+01
.ENDS GRJ31BR72E223KWJ1

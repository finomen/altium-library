*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X8L(-55to150[deg])/5.60e-01[uF]/25[V]
* Murata P/N :GCJ31CL81E564KA01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CL81E564KA01 Port1 Port2
C01 Port1 N01 5.47e-07
R01 Port1 N01 8.93e+08
L02 N01 N02 1.19e-10
R03 N02 N03 9.29e-03
C04 N03 N04 7.92e-05
R04 N03 N04 2.93e+01
C05 N04 N05 8.33e-05
R05 N04 N05 3.86e+00
C06 N05 N06 7.01e-05
R06 N05 N06 4.43e-01
C07 N06 N07 1.12e-04
R07 N06 N07 4.33e-02
C08 N07 N08 3.87e-05
R08 N07 N08 2.45e-02
L09 N08 N09 1.42e-11
R09 N08 N09 6.03e-02
L10 N09 N10 2.83e-10
R10 N09 N10 5.57e-02
C11 N10 N11 2.41e-06
L11 N10 N11 5.12e-11
R11 N10 N11 1.91e-02
C12 N11 N12 8.27e-07
L12 N11 N12 6.00e-11
R12 N11 N12 2.09e-02
C13 N12 N13 1.41e-11
L13 N12 N13 1.48e-10
R13 N12 N13 2.60e+01
C14 N13 N14 3.48e-12
L14 N13 N14 2.86e-10
R14 N13 N14 5.05e+01
C15 N14 Port2 2.16e-12
L15 N14 Port2 1.58e-10
R15 N14 Port2 1.81e+01
.ENDS GCJ31CL81E564KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/4.70e-02[uF]/450[V]
* Murata P/N :GC331CD72W473KX03
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331CD72W473KX03 Port1 Port2
C01 Port1 N01 4.73e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 5.21e-10
R03 N02 N03 1.42e-02
C04 N03 N04 1.61e-05
R04 N03 N04 1.40e+02
C05 N04 N05 2.20e-05
R05 N04 N05 1.90e+01
C06 N05 N06 2.07e-05
R06 N05 N06 3.99e+00
C07 N06 N07 1.86e-05
R07 N06 N07 8.14e-01
C08 N07 N08 1.50e-05
R08 N07 N08 1.65e-01
C09 N08 N09 1.23e-05
R09 N08 N09 2.60e-02
L10 N09 N10 1.31e-10
R10 N09 N10 1.35e-01
L11 N10 N11 3.84e-11
R11 N10 N11 4.68e-02
C12 N11 N12 2.47e-07
L12 N11 N12 4.59e-11
R12 N11 N12 9.83e-02
C13 N12 N13 5.38e-08
L13 N12 N13 9.51e-11
R13 N12 N13 1.11e-01
C14 N13 Port2 2.16e-11
L14 N13 Port2 8.79e-11
R14 N13 Port2 3.76e+00
.ENDS GC331CD72W473KX03

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/1000[V]
* Murata P/N :GRJ31BR73A332KWJ1
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A332KWJ1 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.73e-10
R03 N02 N03 1.83e-01
C04 N03 N04 3.72e-07
R04 N03 N04 4.33e+03
C05 N04 N05 4.60e-07
R05 N04 N05 6.02e+02
C06 N05 N06 3.99e-07
R06 N05 N06 1.23e+02
C07 N06 N07 3.60e-07
R07 N06 N07 2.21e+01
C08 N07 N08 3.57e-07
R08 N07 N08 4.28e+00
C09 N08 N09 2.44e-07
R09 N08 N09 1.03e+00
C10 N09 N10 9.08e-08
R10 N09 N10 2.86e-01
L11 N10 N11 2.09e-11
R11 N10 N11 1.54e-01
L12 N11 N12 1.33e-11
R12 N11 N12 1.20e-01
C13 N12 N13 4.45e-09
L13 N12 N13 1.41e-11
R13 N12 N13 1.01e-01
C14 N13 N14 8.51e-10
L14 N13 N14 7.06e-12
R14 N13 N14 2.60e-01
C15 N14 Port2 7.46e-12
L15 N14 Port2 3.71e-10
R15 N14 Port2 2.30e+01
.ENDS GRJ31BR73A332KWJ1

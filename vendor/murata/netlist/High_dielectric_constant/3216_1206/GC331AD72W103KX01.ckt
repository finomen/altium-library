*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/1.00e-02[uF]/450[V]
* Murata P/N :GC331AD72W103KX01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331AD72W103KX01 Port1 Port2
C01 Port1 N01 9.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.86e-10
R03 N02 N03 4.86e-02
C04 N03 N04 2.49e-06
R04 N03 N04 1.55e+03
C05 N04 N05 4.21e-06
R05 N04 N05 1.26e+02
C06 N05 N06 4.36e-06
R06 N05 N06 2.49e+01
C07 N06 N07 4.21e-06
R07 N06 N07 5.42e+00
C08 N07 N08 3.65e-06
R08 N07 N08 1.20e+00
C09 N08 N09 3.11e-06
R09 N08 N09 2.57e-01
C10 N09 N10 2.08e-06
R10 N09 N10 6.26e-02
L11 N10 N11 8.91e-11
R11 N10 N11 2.10e-01
L12 N11 N12 2.24e-11
R12 N11 N12 4.10e-02
C13 N12 N13 7.43e-08
L13 N12 N13 1.21e-11
R13 N12 N13 3.30e-02
C14 N13 N14 2.03e-08
L14 N13 N14 1.34e-11
R14 N13 N14 6.05e-02
C15 N14 N15 4.26e-10
L15 N14 N15 1.72e-11
R15 N14 N15 2.74e-01
C16 N15 Port2 9.22e-12
L16 N15 Port2 2.36e-10
R16 N15 Port2 2.34e+01
.ENDS GC331AD72W103KX01

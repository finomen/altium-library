*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7T(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :GC331CD72J153KX03
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC331CD72J153KX03 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 6.67e+09
L02 N01 N02 4.70e-10
R03 N02 N03 2.78e-02
C04 N03 N04 4.60e-06
R04 N03 N04 8.96e+02
C05 N04 N05 7.53e-06
R05 N04 N05 7.97e+01
C06 N05 N06 7.61e-06
R06 N05 N06 1.65e+01
C07 N06 N07 7.37e-06
R07 N06 N07 3.69e+00
C08 N07 N08 6.45e-06
R08 N07 N08 8.59e-01
C09 N08 N09 5.47e-06
R09 N08 N09 1.90e-01
C10 N09 N10 4.60e-06
R10 N09 N10 3.99e-02
L11 N10 N11 6.58e-11
R11 N10 N11 1.77e-01
L12 N11 N12 3.94e-11
R12 N11 N12 7.14e-02
C13 N12 N13 1.05e-07
L13 N12 N13 2.85e-11
R13 N12 N13 9.56e-02
C14 N13 N14 1.63e-08
L14 N13 N14 6.99e-11
R14 N13 N14 1.31e-01
C15 N14 N15 4.87e-10
L15 N14 N15 1.40e-11
R15 N14 N15 2.77e-01
C16 N15 Port2 7.52e-12
L16 N15 Port2 2.74e-10
R16 N15 Port2 2.61e+01
.ENDS GC331CD72J153KX03

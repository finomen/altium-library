*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GCJ31CR71A106MA13
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR71A106MA13 Port1 Port2
C01 Port1 N01 9.45e-06
R01 Port1 N01 5.00e+07
L02 N01 N02 2.10e-10
R03 N02 N03 6.84e-03
C04 N03 N04 1.33e-03
R04 N03 N04 1.91e+00
C05 N04 N05 1.35e-03
R05 N04 N05 2.58e-01
C06 N05 N06 1.34e-03
R06 N05 N06 4.59e-02
C07 N06 N07 2.28e-03
R07 N06 N07 6.76e-03
C08 N07 N08 8.49e-04
R08 N07 N08 3.95e-03
L09 N08 N09 3.15e-11
R09 N08 N09 8.48e-02
L10 N09 N10 7.11e-11
R10 N09 N10 2.69e-02
L11 N10 N11 5.04e-10
R11 N10 N11 2.06e-02
C12 N11 N12 3.00e-05
L12 N11 N12 1.14e-10
R12 N11 N12 6.41e-03
C13 N12 N13 1.38e-05
L13 N12 N13 1.12e-10
R13 N12 N13 7.23e-03
C14 N13 Port2 1.36e-12
L14 N13 Port2 1.81e-10
R14 N13 Port2 2.70e+01
.ENDS GCJ31CR71A106MA13

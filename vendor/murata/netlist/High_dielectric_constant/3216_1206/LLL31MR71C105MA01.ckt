*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/1.00e+00[uF]/16[V]
* Murata P/N :LLL31MR71C105MA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL31MR71C105MA01 Port1 Port2
C01 Port1 N01 9.85e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 4.36e-11
R03 N02 N03 1.98e-03
C04 N03 N04 1.48e-04
R04 N03 N04 2.37e+01
C05 N04 N05 2.05e-04
R05 N04 N05 2.45e+00
C06 N05 N06 1.72e-04
R06 N05 N06 7.17e-01
C07 N06 N07 1.47e-04
R07 N06 N07 1.61e-01
C08 N07 N08 1.17e-04
R08 N07 N08 3.18e-02
C09 N08 N09 7.87e-05
R09 N08 N09 6.23e-03
L10 N09 N10 8.22e-11
R10 N09 N10 3.26e-02
L11 N10 N11 5.10e-12
R11 N10 N11 2.95e-02
C12 N11 N12 1.12e-06
L12 N11 N12 7.91e-11
R12 N11 N12 5.47e-02
C13 N12 N13 9.41e-07
L13 N12 N13 3.61e-11
R13 N12 N13 3.33e-02
C14 N13 N14 5.19e-07
L14 N13 N14 2.99e-11
R14 N13 N14 1.76e-02
C15 N14 Port2 1.08e-11
L15 N14 Port2 3.40e-11
R15 N14 Port2 7.19e+00
.ENDS LLL31MR71C105MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.90e-01[uF]/50[V]
* Murata P/N :GCJ31MR71H394MA01
* Property : C = 3.90e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31MR71H394MA01 Port1 Port2
C01 Port1 N01 4.12e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.38e-10
R03 N02 N03 2.37e-02
C04 N03 N04 4.33e-05
R04 N03 N04 9.20e+01
C05 N04 N05 6.44e-05
R05 N04 N05 8.99e+00
C06 N05 N06 5.34e-05
R06 N05 N06 1.36e+00
C07 N06 N07 5.22e-05
R07 N06 N07 1.30e-01
C08 N07 N08 5.54e-05
R08 N07 N08 2.87e-02
C09 N08 N09 3.58e-05
R09 N08 N09 8.03e-03
L10 N09 N10 2.00e-11
R10 N09 N10 7.60e-02
L11 N10 N11 1.80e-10
R11 N10 N11 6.97e-02
C12 N11 N12 2.48e-06
L12 N11 N12 3.09e-11
R12 N11 N12 1.36e-02
C13 N12 N13 2.67e-07
L13 N12 N13 9.74e-11
R13 N12 N13 2.67e-02
C14 N13 N14 2.20e-11
L14 N13 N14 7.17e-11
R14 N13 N14 6.60e+00
C15 N14 Port2 1.12e-12
L15 N14 Port2 3.79e-10
R15 N14 Port2 8.71e+01
.ENDS GCJ31MR71H394MA01

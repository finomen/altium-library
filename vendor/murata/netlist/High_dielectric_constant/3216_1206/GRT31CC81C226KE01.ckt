*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X6S(-55to105[deg])/2.20e+01[uF]/16[V]
* Murata P/N :GRT31CC81C226KE01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT31CC81C226KE01 Port1 Port2
C01 Port1 N01 1.67e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.25e-10
R03 N02 N03 2.67e-03
C04 N03 N04 7.28e-04
R04 N03 N04 7.29e+00
C05 N04 N05 9.02e-04
R05 N04 N05 6.39e-01
C06 N05 N06 8.82e-04
R06 N05 N06 8.49e-02
C07 N06 N07 9.22e-04
R07 N06 N07 9.90e-03
C08 N07 N08 1.19e-03
R08 N07 N08 1.51e-03
L09 N08 N09 1.86e-11
R09 N08 N09 4.09e-02
L10 N09 N10 7.24e-11
R10 N09 N10 2.33e-02
L11 N10 N11 4.61e-10
R11 N10 N11 1.35e-02
C12 N11 N12 5.37e-05
L12 N11 N12 7.58e-11
R12 N11 N12 3.38e-03
C13 N12 N13 3.02e-05
L13 N12 N13 7.06e-11
R13 N12 N13 3.61e-03
C14 N13 N14 1.91e-11
L14 N13 N14 8.07e-11
R14 N13 N14 5.63e+00
C15 N14 Port2 1.75e-12
L15 N14 Port2 2.67e-10
R15 N14 Port2 1.35e+02
.ENDS GRT31CC81C226KE01

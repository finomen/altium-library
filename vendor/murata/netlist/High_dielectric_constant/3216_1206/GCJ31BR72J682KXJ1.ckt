*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J682KXJ1
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J682KXJ1 Port1 Port2
C01 Port1 N01 7.05e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.86e-10
R03 N02 N03 1.04e-01
C04 N03 N04 7.54e-07
R04 N03 N04 2.31e+03
C05 N04 N05 9.08e-07
R05 N04 N05 3.94e+02
C06 N05 N06 7.72e-07
R06 N05 N06 8.52e+01
C07 N06 N07 7.02e-07
R07 N06 N07 1.63e+01
C08 N07 N08 5.45e-07
R08 N07 N08 3.26e+00
C09 N08 N09 4.28e-07
R09 N08 N09 5.92e-01
C10 N09 N10 2.62e-07
R10 N09 N10 1.38e-01
L11 N10 N11 6.23e-11
R11 N10 N11 3.94e-01
L12 N11 N12 4.64e-11
R12 N11 N12 1.45e-01
C13 N12 N13 7.24e-08
L13 N12 N13 9.14e-12
R13 N12 N13 3.97e-02
C14 N13 N14 1.17e-08
L14 N13 N14 1.79e-11
R14 N13 N14 9.83e-02
C15 N14 Port2 1.01e-11
L15 N14 Port2 2.30e-10
R15 N14 Port2 1.66e+01
.ENDS GCJ31BR72J682KXJ1

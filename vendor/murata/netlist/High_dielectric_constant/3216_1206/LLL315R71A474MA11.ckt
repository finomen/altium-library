*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/4.70e-01[uF]/10[V]
* Murata P/N :LLL315R71A474MA11
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL315R71A474MA11 Port1 Port2
C01 Port1 N01 4.31e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 4.35e-11
R03 N02 N03 2.60e-03
C04 N03 N04 5.53e-05
R04 N03 N04 7.19e+01
C05 N04 N05 5.47e-05
R05 N04 N05 1.14e+01
C06 N05 N06 6.59e-05
R06 N05 N06 1.28e+00
C07 N06 N07 5.76e-05
R07 N06 N07 2.86e-01
C08 N07 N08 4.80e-05
R08 N07 N08 4.16e-02
C09 N08 N09 3.40e-05
R09 N08 N09 7.72e-03
C10 N09 N10 1.11e-05
R10 N09 N10 1.80e-03
L11 N10 N11 6.21e-12
R11 N10 N11 3.99e-02
L12 N11 N12 4.28e-11
R12 N11 N12 2.87e-02
C13 N12 N13 5.82e-07
L13 N12 N13 2.36e-11
R13 N12 N13 1.86e-02
C14 N13 N14 2.06e-07
L14 N13 N14 1.92e-11
R14 N13 N14 1.27e-02
C15 N14 Port2 1.15e-11
L15 N14 Port2 4.29e-11
R15 N14 Port2 6.17e+00
.ENDS LLL315R71A474MA11

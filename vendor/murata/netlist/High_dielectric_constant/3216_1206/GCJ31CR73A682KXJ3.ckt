*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-03[uF]/1000[V]
* Murata P/N :GCJ31CR73A682KXJ3
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR73A682KXJ3 Port1 Port2
C01 Port1 N01 7.05e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 5.24e-10
R03 N02 N03 8.90e-02
C04 N03 N04 8.97e-07
R04 N03 N04 2.15e+03
C05 N04 N05 1.10e-06
R05 N04 N05 3.35e+02
C06 N05 N06 9.61e-07
R06 N05 N06 7.09e+01
C07 N06 N07 8.88e-07
R07 N06 N07 1.37e+01
C08 N07 N08 7.16e-07
R08 N07 N08 2.84e+00
C09 N08 N09 4.75e-07
R09 N08 N09 6.17e-01
C10 N09 N10 2.87e-07
R10 N09 N10 1.10e-01
L11 N10 N11 3.94e-11
R11 N10 N11 3.22e-01
L12 N11 N12 6.34e-11
R12 N11 N12 1.77e-01
C13 N12 N13 5.57e-08
L13 N12 N13 1.87e-11
R13 N12 N13 6.82e-02
C14 N13 N14 1.08e-08
L14 N13 N14 3.53e-11
R14 N13 N14 1.35e-01
C15 N14 Port2 1.12e-11
L15 N14 Port2 2.07e-10
R15 N14 Port2 1.67e+01
.ENDS GCJ31CR73A682KXJ3

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :GRJ31CZ72A475KE01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CZ72A475KE01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 9.05e-11
R03 N02 N03 8.01e-03
C04 N03 N04 3.70e-04
R04 N03 N04 1.43e+01
C05 N04 N05 4.47e-04
R05 N04 N05 1.41e+00
C06 N05 N06 3.64e-04
R06 N05 N06 2.06e-01
C07 N06 N07 3.43e-04
R07 N06 N07 2.16e-02
C08 N07 N08 2.47e-04
R08 N07 N08 3.09e-03
L09 N08 N09 1.90e-11
R09 N08 N09 5.93e-02
L10 N09 N10 4.79e-11
R10 N09 N10 2.60e-02
L11 N10 N11 4.23e-10
R11 N10 N11 2.36e-02
C12 N11 N12 1.10e-05
L12 N11 N12 1.10e-10
R12 N11 N12 9.95e-03
C13 N12 N13 7.92e-06
L13 N12 N13 6.98e-11
R13 N12 N13 8.94e-03
C14 N13 Port2 1.27e-12
L14 N13 Port2 3.56e-10
R14 N13 Port2 1.06e+02
.ENDS GRJ31CZ72A475KE01

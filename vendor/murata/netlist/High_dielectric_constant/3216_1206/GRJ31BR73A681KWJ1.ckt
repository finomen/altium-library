*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/6.80e-04[uF]/1000[V]
* Murata P/N :GRJ31BR73A681KWJ1
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR73A681KWJ1 Port1 Port2
C01 Port1 N01 6.88e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.46e-10
R03 N02 N03 3.70e-01
C04 N03 N04 9.47e-08
R04 N03 N04 1.74e+04
C05 N04 N05 9.83e-08
R05 N04 N05 4.08e+03
C06 N05 N06 8.59e-08
R06 N05 N06 8.58e+02
C07 N06 N07 8.47e-08
R07 N06 N07 1.59e+02
C08 N07 N08 6.84e-08
R08 N07 N08 3.36e+01
C09 N08 N09 4.81e-08
R09 N08 N09 7.05e+00
C10 N09 N10 3.07e-08
R10 N09 N10 1.63e+00
C11 N10 N11 8.79e-09
R11 N10 N11 4.26e-01
C12 N11 N12 3.64e-10
L12 N11 N12 2.58e-11
R12 N11 N12 6.21e-01
C13 N12 Port2 5.92e-12
L13 N12 Port2 4.42e-10
R13 N12 Port2 2.00e+01
.ENDS GRJ31BR73A681KWJ1

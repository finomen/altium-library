*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e-01[uF]/16[V]
* Murata P/N :LLL317R71C224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R71C224MA01 Port1 Port2
C01 Port1 N01 2.22e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.77e-12
R03 N02 N03 4.60e-03
C04 N03 N04 2.72e-05
R04 N03 N04 1.46e+02
C05 N04 N05 4.06e-05
R05 N04 N05 2.07e+01
C06 N05 N06 3.38e-05
R06 N05 N06 3.35e+00
C07 N06 N07 3.15e-05
R07 N06 N07 6.54e-01
C08 N07 N08 2.82e-05
R08 N07 N08 7.33e-02
C09 N08 N09 2.10e-05
R09 N08 N09 1.87e-02
C10 N09 N10 1.39e-05
R10 N09 N10 4.22e-03
L11 N10 N11 3.50e-11
R11 N10 N11 4.48e-02
C12 N11 N12 3.21e-07
L12 N11 N12 2.55e-11
R12 N11 N12 2.63e-02
C13 N12 N13 7.79e-08
L13 N12 N13 2.76e-11
R13 N12 N13 2.26e-02
C14 N13 N14 1.10e-11
L14 N13 N14 6.35e-11
R14 N13 N14 1.05e+01
C15 N14 Port2 3.54e-12
L15 N14 Port2 6.43e-11
R15 N14 Port2 1.20e+01
.ENDS LLL317R71C224MA01

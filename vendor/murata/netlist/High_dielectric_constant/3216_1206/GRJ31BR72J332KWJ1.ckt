*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-03[uF]/630[V]
* Murata P/N :GRJ31BR72J332KWJ1
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31BR72J332KWJ1 Port1 Port2
C01 Port1 N01 3.39e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.68e-10
R03 N02 N03 1.53e-01
C04 N03 N04 3.71e-07
R04 N03 N04 4.42e+03
C05 N04 N05 4.60e-07
R05 N04 N05 5.99e+02
C06 N05 N06 4.00e-07
R06 N05 N06 1.21e+02
C07 N06 N07 3.56e-07
R07 N06 N07 2.20e+01
C08 N07 N08 2.75e-07
R08 N07 N08 4.19e+00
C09 N08 N09 1.67e-07
R09 N08 N09 8.13e-01
C10 N09 N10 8.94e-08
R10 N09 N10 1.41e-01
L11 N10 N11 1.08e-10
R11 N10 N11 1.01e+00
L12 N11 N12 5.58e-11
R12 N11 N12 5.14e-01
C13 N12 N13 2.05e-08
L13 N12 N13 7.19e-12
R13 N12 N13 7.47e-02
C14 N13 N14 2.07e-09
L14 N13 N14 3.96e-11
R14 N13 N14 2.91e-01
C15 N14 Port2 9.77e-12
L15 N14 Port2 2.26e-10
R15 N14 Port2 1.68e+01
.ENDS GRJ31BR72J332KWJ1

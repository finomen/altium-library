*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+01[uF]/10[V]
* Murata P/N :GRJ31CR71A226KE12
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ31CR71A226KE12 Port1 Port2
C01 Port1 N01 1.70e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.64e-11
R03 N02 N03 4.68e-03
C04 N03 N04 3.12e-04
R04 N03 N04 1.63e+01
C05 N04 N05 4.46e-04
R05 N04 N05 9.80e-01
C06 N05 N06 4.06e-04
R06 N05 N06 1.09e-01
C07 N06 N07 3.97e-04
R07 N06 N07 1.08e-02
C08 N07 N08 2.72e-04
R08 N07 N08 2.42e-03
L09 N08 N09 1.74e-11
R09 N08 N09 7.27e-02
L10 N09 N10 7.97e-11
R10 N09 N10 3.89e-02
L11 N10 N11 5.64e-10
R11 N10 N11 1.39e-02
C12 N11 N12 5.13e-05
L12 N11 N12 8.38e-11
R12 N11 N12 4.28e-03
C13 N12 N13 4.15e-05
L13 N12 N13 4.86e-11
R13 N12 N13 3.96e-03
C14 N13 N14 1.88e-11
L14 N13 N14 5.51e-11
R14 N13 N14 6.71e+00
C15 N14 Port2 1.01e-12
L15 N14 Port2 3.65e-10
R15 N14 Port2 1.40e+02
.ENDS GRJ31CR71A226KE12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/1.00e-03[uF]/630[V]
* Murata P/N :GCJ31BR72J102KXJ1
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31BR72J102KXJ1 Port1 Port2
C01 Port1 N01 1.04e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.22e-10
R03 N02 N03 3.40e-01
C04 N03 N04 1.38e-07
R04 N03 N04 1.53e+04
C05 N04 N05 1.85e-07
R05 N04 N05 2.08e+03
C06 N05 N06 1.58e-07
R06 N05 N06 4.75e+02
C07 N06 N07 1.50e-07
R07 N06 N07 9.34e+01
C08 N07 N08 1.24e-07
R08 N07 N08 2.01e+01
C09 N08 N09 8.82e-08
R09 N08 N09 4.53e+00
C10 N09 N10 5.06e-08
R10 N09 N10 1.07e+00
C11 N10 N11 1.38e-08
R11 N10 N11 3.55e-01
L12 N11 N12 1.06e-10
R12 N11 N12 1.46e+00
L13 N12 N13 5.85e-11
R13 N12 N13 1.11e+00
C14 N13 N14 8.94e-10
L14 N13 N14 4.29e-11
R14 N13 N14 5.25e-01
C15 N14 Port2 1.19e-11
L15 N14 Port2 1.67e-10
R15 N14 Port2 7.98e+00
.ENDS GCJ31BR72J102KXJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/2.20e+00[uF]/100[V]
* Murata P/N :KRM31KR72A225KH01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM31KR72A225KH01 Port1 Port2
C01 Port1 N01 2.16e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 3.59e-11
R03 N02 N03 7.01e-03
C04 N03 N04 3.81e-04
R04 N03 N04 6.27e-01
C05 N04 N05 3.10e-04
R05 N04 N05 9.47e-02
C06 N05 N06 2.59e-04
R06 N05 N06 1.58e-02
L07 N06 N07 5.95e-11
R07 N06 N07 1.82e-01
L08 N07 N08 2.59e-10
R08 N07 N08 3.87e-02
L09 N08 N09 2.25e-10
R09 N08 N09 6.53e-03
C10 N09 N10 8.63e-06
L10 N09 N10 6.10e-11
R10 N09 N10 8.01e-03
C11 N10 N11 2.11e-06
L11 N10 N11 1.01e-10
R11 N10 N11 1.45e-02
C12 N11 N12 9.75e-12
L12 N11 N12 1.51e-10
R12 N11 N12 1.78e+01
C13 N12 Port2 5.14e-13
L13 N12 Port2 1.26e-09
R13 N12 Port2 3.04e+02
.ENDS KRM31KR72A225KH01

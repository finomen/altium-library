*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1632M(0612)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :LLL317R70J225MA01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL317R70J225MA01 Port1 Port2
C01 Port1 N01 2.08e-06
R01 Port1 N01 2.27e+08
L02 N01 N02 3.50e-11
R03 N02 N03 2.31e-03
C04 N03 N04 4.09e-04
R04 N03 N04 1.25e+01
C05 N04 N05 3.87e-04
R05 N04 N05 1.74e+00
C06 N05 N06 2.55e-04
R06 N05 N06 3.81e-01
C07 N06 N07 2.52e-04
R07 N06 N07 5.57e-02
C08 N07 N08 2.38e-04
R08 N07 N08 8.48e-03
C09 N08 N09 2.00e-04
R09 N08 N09 2.55e-03
L10 N09 N10 1.49e-11
R10 N09 N10 7.48e-02
L11 N10 N11 5.38e-11
R11 N10 N11 1.60e-02
C12 N11 N12 3.46e-06
L12 N11 N12 2.54e-11
R12 N11 N12 8.58e-03
C13 N12 N13 1.44e-06
L13 N12 N13 1.85e-11
R13 N12 N13 5.52e-03
C14 N13 Port2 7.21e-12
L14 N13 Port2 6.21e-11
R14 N13 Port2 1.04e+01
.ENDS LLL317R70J225MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/X7R(-55to125[deg])/3.30e-02[uF]/250[V]
* Murata P/N :GCJ31CR72E333KXJ3
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ31CR72E333KXJ3 Port1 Port2
C01 Port1 N01 3.36e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 4.82e-10
R03 N02 N03 5.25e-02
C04 N03 N04 4.09e-06
R04 N03 N04 5.22e+02
C05 N04 N05 4.27e-06
R05 N04 N05 1.32e+02
C06 N05 N06 3.83e-06
R06 N05 N06 2.89e+01
C07 N06 N07 3.64e-06
R07 N06 N07 6.23e+00
C08 N07 N08 3.17e-06
R08 N07 N08 1.35e+00
C09 N08 N09 2.81e-06
R09 N08 N09 3.11e-01
C10 N09 N10 1.75e-06
R10 N09 N10 6.37e-02
L11 N10 N11 4.98e-11
R11 N10 N11 2.66e-01
L12 N11 N12 7.90e-11
R12 N11 N12 7.13e-02
C13 N12 N13 2.87e-07
L13 N12 N13 1.22e-11
R13 N12 N13 1.78e-02
C14 N13 N14 3.21e-08
L14 N13 N14 3.81e-11
R14 N13 N14 4.98e-02
C15 N14 Port2 8.17e-12
L15 N14 Port2 3.07e-10
R15 N14 Port2 3.30e+01
.ENDS GCJ31CR72E333KXJ3

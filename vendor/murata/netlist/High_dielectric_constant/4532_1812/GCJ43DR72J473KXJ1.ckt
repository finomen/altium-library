*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :GCJ43DR72J473KXJ1
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR72J473KXJ1 Port1 Port2
C01 Port1 N01 5.07e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 3.81e-10
R03 N02 N03 2.55e-02
C04 N03 N04 8.35e-06
R04 N03 N04 1.90e+02
C05 N04 N05 6.20e-06
R05 N04 N05 1.11e+02
C06 N05 N06 5.82e-06
R06 N05 N06 2.10e+01
C07 N06 N07 5.75e-06
R07 N06 N07 4.75e+00
C08 N07 N08 4.85e-06
R08 N07 N08 1.09e+00
C09 N08 N09 4.33e-06
R09 N08 N09 2.50e-01
C10 N09 N10 2.73e-06
R10 N09 N10 5.06e-02
L11 N10 N11 4.68e-11
R11 N10 N11 1.38e-01
L12 N11 N12 1.08e-10
R12 N11 N12 1.34e-01
C13 N12 N13 1.28e-07
L13 N12 N13 6.80e-11
R13 N12 N13 1.11e-01
C14 N13 N14 3.44e-08
L14 N13 N14 8.76e-11
R14 N13 N14 1.05e-01
C15 N14 Port2 1.39e-11
L15 N14 Port2 1.33e-10
R15 N14 Port2 1.07e+01
.ENDS GCJ43DR72J473KXJ1

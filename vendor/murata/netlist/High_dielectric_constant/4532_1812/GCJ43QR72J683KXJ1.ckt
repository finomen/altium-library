*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/6.80e-02[uF]/630[V]
* Murata P/N :GCJ43QR72J683KXJ1
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43QR72J683KXJ1 Port1 Port2
C01 Port1 N01 7.26e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 3.78e-10
R03 N02 N03 2.09e-02
C04 N03 N04 6.85e-06
R04 N03 N04 1.04e+02
C05 N04 N05 2.80e-05
R05 N04 N05 2.45e+01
C06 N05 N06 9.57e-06
R06 N05 N06 1.57e+01
C07 N06 N07 7.28e-06
R07 N06 N07 4.70e+00
C08 N07 N08 7.07e-06
R08 N07 N08 9.85e-01
C09 N08 N09 6.23e-06
R09 N08 N09 2.38e-01
C10 N09 N10 3.59e-06
R10 N09 N10 5.21e-02
L11 N10 N11 8.77e-11
R11 N10 N11 1.09e-01
L12 N11 N12 2.42e-11
R12 N11 N12 8.53e-02
C13 N12 N13 1.90e-07
L13 N12 N13 4.82e-11
R13 N12 N13 7.85e-02
C14 N13 N14 3.17e-08
L14 N13 N14 9.74e-11
R14 N13 N14 9.21e-02
C15 N14 Port2 1.75e-11
L15 N14 Port2 1.27e-10
R15 N14 Port2 1.30e+01
.ENDS GCJ43QR72J683KXJ1

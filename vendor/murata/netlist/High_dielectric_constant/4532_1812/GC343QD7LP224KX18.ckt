*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7T(-55to125[deg])/2.20e-01[uF]/450[V]
* Murata P/N :GC343QD7LP224KX18
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC343QD7LP224KX18 Port1 Port2
C01 Port1 N01 2.13e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.20e-10
R03 N02 N03 7.16e-03
C04 N03 N04 7.82e-05
R04 N03 N04 3.23e+01
C05 N04 N05 1.04e-04
R05 N04 N05 4.94e+00
C06 N05 N06 9.51e-05
R06 N05 N06 1.10e+00
C07 N06 N07 8.14e-05
R07 N06 N07 2.48e-01
C08 N07 N08 6.06e-05
R08 N07 N08 5.45e-02
C09 N08 N09 7.44e-05
R09 N08 N09 6.91e-03
L10 N09 N10 1.59e-11
R10 N09 N10 2.01e-01
L11 N10 N11 7.09e-11
R11 N10 N11 4.76e-02
L12 N11 N12 2.84e-11
R12 N11 N12 1.78e-02
C13 N12 N13 6.01e-07
L13 N12 N13 5.84e-11
R13 N12 N13 5.84e-02
C14 N13 N14 1.60e-07
L14 N13 N14 7.78e-11
R14 N13 N14 5.60e-02
C15 N14 N15 3.20e-09
L15 N14 N15 5.47e-11
R15 N14 N15 2.40e-02
C16 N15 Port2 9.78e-12
L16 N15 Port2 2.33e-10
R16 N15 Port2 2.46e+01
.ENDS GC343QD7LP224KX18

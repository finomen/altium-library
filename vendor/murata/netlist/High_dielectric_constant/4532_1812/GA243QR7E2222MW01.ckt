*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-03[uF]/250[Vac]
* Murata P/N :GA243QR7E2222MW01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243QR7E2222MW01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 4.43e-11
R03 N02 N03 1.49e-01
C04 N03 N04 6.12e-08
R04 N03 N04 3.28e+01
C05 N04 N05 3.76e-07
R05 N04 N05 9.07e-01
C06 N05 N06 1.85e-07
R06 N05 N06 4.63e-01
C07 N06 N07 1.04e-07
R07 N06 N07 1.53e-01
C08 N07 N08 9.06e-08
R08 N07 N08 6.94e-02
L09 N08 N09 8.46e-11
R09 N08 N09 7.87e-01
C10 N09 N10 5.79e-09
L10 N09 N10 6.16e-11
R10 N09 N10 4.23e-01
C11 N10 N11 2.03e-09
L11 N10 N11 2.14e-11
R11 N10 N11 2.61e-01
C12 N11 N12 7.22e-12
L12 N11 N12 2.25e-10
R12 N11 N12 2.44e+01
C13 N12 Port2 3.41e-12
L13 N12 Port2 2.36e-10
R13 N12 Port2 2.71e+01
.ENDS GA243QR7E2222MW01

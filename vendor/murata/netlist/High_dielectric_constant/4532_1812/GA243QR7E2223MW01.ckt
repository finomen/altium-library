*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-02[uF]/250[Vac]
* Murata P/N :GA243QR7E2223MW01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243QR7E2223MW01 Port1 Port2
C01 Port1 N01 2.15e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.78e-10
R03 N02 N03 3.70e-02
C04 N03 N04 1.59e-06
R04 N03 N04 9.99e-01
C05 N04 N05 2.45e-06
R05 N04 N05 9.92e-02
C06 N05 N06 9.98e-07
R06 N05 N06 3.96e-02
L07 N06 N07 1.10e-10
R07 N06 N07 2.38e-01
C08 N07 N08 4.79e-08
L08 N07 N08 4.26e-11
R08 N07 N08 8.28e-02
C09 N08 N09 1.71e-08
L09 N08 N09 3.69e-11
R09 N08 N09 1.05e-01
C10 N09 N10 1.04e-11
L10 N09 N10 2.30e-10
R10 N09 N10 2.22e+01
C11 N10 Port2 4.96e-12
L11 N10 Port2 2.09e-10
R11 N10 Port2 3.76e+01
.ENDS GA243QR7E2223MW01

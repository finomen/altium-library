*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/2.20e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E224KWJ1
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E224KWJ1 Port1 Port2
C01 Port1 N01 2.33e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.71e-10
R03 N02 N03 1.55e-02
C04 N03 N04 2.52e-05
R04 N03 N04 6.59e+01
C05 N04 N05 2.78e-05
R05 N04 N05 1.47e+01
C06 N05 N06 2.36e-05
R06 N05 N06 3.30e+00
C07 N06 N07 2.10e-05
R07 N06 N07 6.61e-01
C08 N07 N08 2.88e-05
R08 N07 N08 9.93e-02
C09 N08 N09 1.65e-05
R09 N08 N09 3.07e-02
L10 N09 N10 4.22e-11
R10 N09 N10 5.48e-02
L11 N10 N11 1.58e-10
R11 N10 N11 4.86e-02
C12 N11 N12 6.60e-07
L12 N11 N12 5.85e-11
R12 N11 N12 3.46e-02
C13 N12 N13 2.33e-07
L13 N12 N13 5.25e-11
R13 N12 N13 3.20e-02
C14 N13 Port2 9.18e-12
L14 N13 Port2 2.53e-10
R14 N13 Port2 2.26e+01
.ENDS GRJ43DR72E224KWJ1

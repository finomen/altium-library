*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E334KWJ1
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E334KWJ1 Port1 Port2
C01 Port1 N01 3.52e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 2.36e-20
R03 N02 N03 1.47e-02
C04 N03 N04 3.70e-05
R04 N03 N04 5.16e+01
C05 N04 N05 3.30e-05
R05 N04 N05 2.05e+01
C06 N05 N06 2.75e-05
R06 N05 N06 4.33e+00
C07 N06 N07 2.56e-05
R07 N06 N07 8.64e-01
C08 N07 N08 3.33e-05
R08 N07 N08 1.48e-01
C09 N08 N09 2.57e-05
R09 N08 N09 2.26e-02
L10 N09 N10 7.04e-10
R10 N09 N10 1.71e+02
L11 N10 N11 2.54e-11
R11 N10 N11 7.51e-02
L12 N11 N12 3.21e-10
R12 N11 N12 5.45e-02
C13 N12 Port2 3.57e-11
L13 N12 Port2 8.19e-11
R13 N12 Port2 8.72e+00
.ENDS GRJ43DR72E334KWJ1

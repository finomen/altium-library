*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7T(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :GC343DD7LQ154KX18
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC343DD7LQ154KX18 Port1 Port2
C01 Port1 N01 1.55e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.70e-10
R03 N02 N03 8.06e-03
C04 N03 N04 6.12e-05
R04 N03 N04 4.41e+01
C05 N04 N05 8.14e-05
R05 N04 N05 6.86e+00
C06 N05 N06 7.26e-05
R06 N05 N06 1.56e+00
C07 N06 N07 6.90e-05
R07 N06 N07 3.25e-01
C08 N07 N08 6.32e-05
R08 N07 N08 7.36e-02
C09 N08 N09 4.98e-05
R09 N08 N09 1.43e-02
L10 N09 N10 6.43e-11
R10 N09 N10 5.62e-02
L11 N10 N11 9.30e-11
R11 N10 N11 4.17e-02
L12 N11 N12 3.37e-11
R12 N11 N12 1.51e-02
C13 N12 N13 3.33e-07
L13 N12 N13 8.66e-11
R13 N12 N13 9.24e-02
C14 N13 N14 1.88e-07
L14 N13 N14 5.81e-11
R14 N13 N14 7.80e-02
C15 N14 Port2 7.43e-12
L15 N14 Port2 3.49e-10
R15 N14 Port2 4.50e+01
.ENDS GC343DD7LQ154KX18

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/1000[V]
* Murata P/N :GCJ43DR73A473KXJ1
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ43DR73A473KXJ1 Port1 Port2
C01 Port1 N01 4.94e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 3.80e-10
R03 N02 N03 2.55e-02
C04 N03 N04 7.83e-06
R04 N03 N04 2.79e+02
C05 N04 N05 7.51e-06
R05 N04 N05 8.24e+01
C06 N05 N06 6.93e-06
R06 N05 N06 1.77e+01
C07 N06 N07 6.70e-06
R07 N06 N07 3.95e+00
C08 N07 N08 5.79e-06
R08 N07 N08 8.86e-01
C09 N08 N09 5.11e-06
R09 N08 N09 2.09e-01
C10 N09 N10 3.35e-06
R10 N09 N10 4.31e-02
L11 N10 N11 4.71e-11
R11 N10 N11 1.46e-01
L12 N11 N12 1.13e-10
R12 N11 N12 1.32e-01
C13 N12 N13 1.25e-07
L13 N12 N13 6.96e-11
R13 N12 N13 1.12e-01
C14 N13 N14 3.61e-08
L14 N13 N14 8.32e-11
R14 N13 N14 1.05e-01
C15 N14 Port2 1.39e-11
L15 N14 Port2 1.34e-10
R15 N14 Port2 1.10e+01
.ENDS GCJ43DR73A473KXJ1

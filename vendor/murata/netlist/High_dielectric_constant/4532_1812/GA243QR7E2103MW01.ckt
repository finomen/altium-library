*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.00e-02[uF]/250[Vac]
* Murata P/N :GA243QR7E2103MW01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243QR7E2103MW01 Port1 Port2
C01 Port1 N01 9.38e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 6.06e-11
R03 N02 N03 5.43e-02
C04 N03 N04 5.74e-07
R04 N03 N04 2.77e+00
C05 N04 N05 7.61e-07
R05 N04 N05 2.37e-01
C06 N05 N06 6.31e-07
R06 N05 N06 4.09e-02
C07 N06 N07 1.17e-07
R07 N06 N07 3.38e-02
L08 N07 N08 8.87e-11
R08 N07 N08 1.77e-01
C09 N08 N09 2.78e-08
L09 N08 N09 2.72e-11
R09 N08 N09 8.11e-02
C10 N09 N10 6.01e-09
L10 N09 N10 3.84e-11
R10 N09 N10 8.42e-02
C11 N10 N11 1.34e-11
L11 N10 N11 2.09e-10
R11 N10 N11 2.29e+01
C12 N11 Port2 3.18e-12
L12 N11 Port2 4.47e-10
R12 N11 Port2 2.46e+01
.ENDS GA243QR7E2103MW01

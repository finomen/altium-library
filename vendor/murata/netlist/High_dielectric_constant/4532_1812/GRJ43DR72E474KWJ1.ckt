*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :GRJ43DR72E474KWJ1
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ43DR72E474KWJ1 Port1 Port2
C01 Port1 N01 4.81e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 4.23e-10
R03 N02 N03 9.39e-03
C04 N03 N04 5.32e-05
R04 N03 N04 3.63e+01
C05 N04 N05 4.82e-05
R05 N04 N05 1.27e+01
C06 N05 N06 4.26e-05
R06 N05 N06 2.59e+00
C07 N06 N07 3.80e-05
R07 N06 N07 5.94e-01
C08 N07 N08 5.22e-05
R08 N07 N08 9.15e-02
C09 N08 N09 3.49e-05
R09 N08 N09 1.97e-02
L10 N09 N10 2.19e-11
R10 N09 N10 1.53e-01
L11 N10 N11 1.69e-10
R11 N10 N11 4.07e-02
L12 N11 N12 5.03e-11
R12 N11 N12 2.62e-02
C13 N12 N13 8.68e-07
L13 N12 N13 9.64e-11
R13 N12 N13 3.22e-02
C14 N13 N14 5.82e-07
L14 N13 N14 5.35e-11
R14 N13 N14 2.63e-02
C15 N14 Port2 2.37e-11
L15 N14 Port2 8.77e-11
R15 N14 Port2 5.65e+00
.ENDS GRJ43DR72E474KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-03[uF]/250[Vac]
* Murata P/N :GA243DR7E2472MW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243DR7E2472MW01 Port1 Port2
C01 Port1 N01 4.77e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 1.45e-11
R03 N02 N03 7.46e-02
C04 N03 N04 2.21e-07
R04 N03 N04 7.20e+00
C05 N04 N05 5.72e-07
R05 N04 N05 2.87e-01
C06 N05 N06 5.38e-07
R06 N05 N06 1.63e-01
C07 N06 N07 1.16e-07
R07 N06 N07 9.00e-02
L08 N07 N08 1.29e-10
R08 N07 N08 5.74e-01
C09 N08 N09 9.66e-09
L09 N08 N09 1.01e-10
R09 N08 N09 4.17e-01
C10 N09 N10 2.96e-09
L10 N09 N10 7.24e-11
R10 N09 N10 3.23e-01
C11 N10 N11 7.76e-12
L11 N10 N11 1.98e-10
R11 N10 N11 2.12e+01
C12 N11 Port2 2.27e-12
L12 N11 Port2 3.49e-10
R12 N11 Port2 2.53e+01
.ENDS GA243DR7E2472MW01

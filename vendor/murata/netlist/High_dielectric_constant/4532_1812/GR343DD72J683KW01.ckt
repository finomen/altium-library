*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7T(-55to125[deg])/6.80e-02[uF]/630[V]
* Murata P/N :GR343DD72J683KW01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR343DD72J683KW01 Port1 Port2
C01 Port1 N01 6.81e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 2.72e-10
R03 N02 N03 1.20e-02
C04 N03 N04 2.99e-05
R04 N03 N04 7.61e+01
C05 N04 N05 3.94e-05
R05 N04 N05 1.09e+01
C06 N05 N06 3.59e-05
R06 N05 N06 2.35e+00
C07 N06 N07 3.28e-05
R07 N06 N07 4.80e-01
C08 N07 N08 2.77e-05
R08 N07 N08 9.75e-02
C09 N08 N09 2.43e-05
R09 N08 N09 1.60e-02
L10 N09 N10 1.04e-10
R10 N09 N10 9.94e-02
L11 N10 N11 4.32e-11
R11 N10 N11 7.47e-02
C12 N11 N12 1.66e-07
L12 N11 N12 6.95e-11
R12 N11 N12 1.19e-01
C13 N12 N13 6.59e-08
L13 N12 N13 6.20e-11
R13 N12 N13 1.09e-01
C14 N13 Port2 7.38e-12
L14 N13 Port2 3.65e-10
R14 N13 Port2 3.99e+01
.ENDS GR343DD72J683KW01

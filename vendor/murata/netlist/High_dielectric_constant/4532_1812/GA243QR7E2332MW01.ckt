*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/3.30e-03[uF]/250[Vac]
* Murata P/N :GA243QR7E2332MW01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243QR7E2332MW01 Port1 Port2
C01 Port1 N01 3.25e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 8.15e-12
R03 N02 N03 1.04e-01
C04 N03 N04 1.17e-07
R04 N03 N04 1.71e+01
C05 N04 N05 4.07e-07
R05 N04 N05 6.86e-01
C06 N05 N06 2.43e-07
R06 N05 N06 3.16e-01
C07 N06 N07 6.91e-08
R07 N06 N07 1.17e-01
L08 N07 N08 8.55e-11
R08 N07 N08 5.49e-01
C09 N08 N09 6.62e-09
L09 N08 N09 6.52e-11
R09 N08 N09 3.36e-01
C10 N09 N10 3.11e-09
L10 N09 N10 3.24e-11
R10 N09 N10 3.17e-01
C11 N10 N11 8.98e-12
L11 N10 N11 2.10e-10
R11 N10 N11 1.87e+01
C12 N11 Port2 2.16e-12
L12 N11 Port2 4.17e-10
R12 N11 Port2 2.72e+01
.ENDS GA243QR7E2332MW01

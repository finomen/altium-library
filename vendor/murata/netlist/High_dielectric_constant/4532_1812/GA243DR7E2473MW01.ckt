*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-02[uF]/250[Vac]
* Murata P/N :GA243DR7E2473MW01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA243DR7E2473MW01 Port1 Port2
C01 Port1 N01 4.62e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 1.40e-11
R03 N02 N03 1.81e-02
C04 N03 N04 4.07e-06
R04 N03 N04 3.91e-01
C05 N04 N05 4.96e-06
R05 N04 N05 6.61e-02
C06 N05 N06 4.43e-06
R06 N05 N06 1.23e-02
C07 N06 N07 1.96e-06
R07 N06 N07 7.89e-03
L08 N07 N08 1.94e-10
R08 N07 N08 1.84e-01
C09 N08 N09 9.97e-08
L09 N08 N09 8.10e-11
R09 N08 N09 1.26e-01
C10 N09 N10 3.88e-08
L10 N09 N10 7.15e-11
R10 N09 N10 9.97e-02
C11 N10 N11 1.52e-11
L11 N10 N11 1.19e-10
R11 N10 N11 1.79e+01
C12 N11 Port2 2.25e-12
L12 N11 Port2 4.20e-10
R12 N11 Port2 3.95e+01
.ENDS GA243DR7E2473MW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7T(-55to125[deg])/3.30e-01[uF]/450[V]
* Murata P/N :GC343DD7LP334KX18
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC343DD7LP334KX18 Port1 Port2
C01 Port1 N01 3.30e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 3.33e-10
R03 N02 N03 5.11e-03
C04 N03 N04 8.79e-05
R04 N03 N04 4.93e+01
C05 N04 N05 1.51e-04
R05 N04 N05 3.56e+00
C06 N05 N06 1.56e-04
R06 N05 N06 7.03e-01
C07 N06 N07 1.35e-04
R07 N06 N07 1.79e-01
C08 N07 N08 7.48e-05
R08 N07 N08 3.28e-02
C09 N08 N09 3.18e-04
R09 N08 N09 1.84e-02
L10 N09 N10 1.17e-10
R10 N09 N10 3.74e-02
L11 N10 N11 6.73e-11
R11 N10 N11 3.28e-02
L12 N11 N12 3.80e-11
R12 N11 N12 1.04e-02
C13 N12 N13 1.01e-06
L13 N12 N13 7.16e-11
R13 N12 N13 7.38e-02
C14 N13 N14 4.05e-07
L14 N13 N14 7.13e-11
R14 N13 N14 6.63e-02
C15 N14 Port2 1.11e-11
L15 N14 Port2 1.88e-10
R15 N14 Port2 1.65e+01
.ENDS GC343DD7LP334KX18

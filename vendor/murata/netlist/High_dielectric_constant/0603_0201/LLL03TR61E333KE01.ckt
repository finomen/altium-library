*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0306M(0102)/X5R(-55to85[deg])/3.30e-02[uF]/25[V]
* Murata P/N :LLL03TR61E333KE01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL03TR61E333KE01 Port1 Port2
C01 Port1 N01 2.56e-08
R01 Port1 N01 1.52e+09
L02 N01 N02 6.66e-11
R03 N02 N03 2.29e-02
C04 N03 N04 9.83e-07
R04 N03 N04 1.25e+03
C05 N04 N05 1.25e-06
R05 N04 N05 2.79e+02
C06 N05 N06 8.98e-07
R06 N05 N06 6.28e+01
C07 N06 N07 8.06e-07
R07 N06 N07 1.06e+01
C08 N07 N08 6.30e-07
R08 N07 N08 2.06e+00
C09 N08 N09 4.60e-07
R09 N08 N09 3.62e-01
C10 N09 N10 3.14e-07
R10 N09 N10 5.66e-02
L11 N10 N11 2.59e-12
R11 N10 N11 1.29e-01
L12 N11 N12 1.65e-11
R12 N11 N12 8.55e-02
C13 N12 N13 1.37e-07
L13 N12 N13 1.79e-12
R13 N12 N13 1.41e-02
C14 N13 Port2 1.72e-08
L14 N13 Port2 5.12e-12
R14 N13 Port2 2.94e-02
.ENDS LLL03TR61E333KE01

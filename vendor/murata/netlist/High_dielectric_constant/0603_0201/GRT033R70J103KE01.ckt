*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X7R(-55to125[deg])/1.00e-02[uF]/6.3[V]
* Murata P/N :GRT033R70J103KE01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R70J103KE01 Port1 Port2
C01 Port1 N01 9.72e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.82e-10
R03 N02 N03 6.24e-02
C04 N03 N04 9.26e-07
R04 N03 N04 4.30e+03
C05 N04 N05 1.42e-06
R05 N04 N05 3.04e+02
C06 N05 N06 1.34e-06
R06 N05 N06 3.66e+01
C07 N06 N07 1.21e-06
R07 N06 N07 4.50e+00
C08 N07 N08 7.77e-07
R08 N07 N08 7.01e-01
C09 N08 N09 5.43e-07
R09 N08 N09 1.12e-01
L10 N09 N10 3.61e-11
R10 N09 N10 1.79e-01
C11 N10 N11 1.33e-08
L11 N10 N11 1.76e-11
R11 N10 N11 2.94e-02
C12 N11 Port2 7.52e-12
L12 N11 Port2 3.27e-11
R12 N11 Port2 4.60e+00
.ENDS GRT033R70J103KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e-03[uF]/25[V]
* Murata P/N :GCH033R61E102KE01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH033R61E102KE01 Port1 Port2
C01 Port1 N01 1.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.87e-01
C04 N03 N04 1.51e-07
R04 N03 N04 5.36e+03
C05 N04 N05 1.59e-07
R05 N04 N05 5.61e+02
C06 N05 N06 1.32e-07
R06 N05 N06 7.39e+01
C07 N06 N07 1.05e-07
R07 N06 N07 9.75e+00
C08 N07 N08 8.37e-08
R08 N07 N08 1.69e+00
C09 N08 N09 7.81e-08
R09 N08 N09 2.79e-01
C10 N09 N10 1.95e-08
R10 N09 N10 1.14e-01
L11 N10 N11 2.94e-11
R11 N10 N11 4.46e-01
C12 N11 N12 1.69e-09
L12 N11 N12 7.76e-12
R12 N11 N12 9.56e-02
C13 N12 Port2 9.33e-12
L13 N12 Port2 2.68e-11
R13 N12 Port2 5.59e+00
.ENDS GCH033R61E102KE01

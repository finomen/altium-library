*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/8.20e-02[uF]/6.3[V]
* Murata P/N :GRT033R60J823KE01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J823KE01 Port1 Port2
C01 Port1 N01 7.87e-08
R01 Port1 N01 6.10e+08
L02 N01 N02 1.74e-10
R03 N02 N03 2.41e-02
C04 N03 N04 6.33e-06
R04 N03 N04 3.18e+02
C05 N04 N05 8.65e-06
R05 N04 N05 4.33e+01
C06 N05 N06 1.03e-05
R06 N05 N06 6.36e+00
C07 N06 N07 1.10e-05
R07 N06 N07 9.66e-01
C08 N07 N08 9.00e-06
R08 N07 N08 1.75e-01
C09 N08 N09 5.19e-06
R09 N08 N09 3.24e-02
L10 N09 N10 2.43e-11
R10 N09 N10 7.62e-01
L11 N10 N11 3.33e-11
R11 N10 N11 8.73e-02
L12 N11 N12 6.42e-11
R12 N11 N12 3.19e-02
C13 N12 Port2 2.22e-07
L13 N12 Port2 1.10e-11
R13 N12 Port2 9.71e-03
.ENDS GRT033R60J823KE01

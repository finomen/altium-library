*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.70e-02[uF]/16[V]
* Murata P/N :GRM033R61C273KE84
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM033R61C273KE84 Port1 Port2
C01 Port1 N01 2.52e-08
R01 Port1 N01 1.85e+09
L02 N01 N02 1.90e-10
R03 N02 N03 3.32e-02
C04 N03 N04 2.31e-06
R04 N03 N04 9.09e+02
C05 N04 N05 2.95e-06
R05 N04 N05 1.78e+02
C06 N05 N06 3.33e-06
R06 N05 N06 3.25e+01
C07 N06 N07 4.07e-06
R07 N06 N07 4.90e+00
C08 N07 N08 3.74e-06
R08 N07 N08 9.60e-01
C09 N08 N09 2.83e-06
R09 N08 N09 2.03e-01
C10 N09 N10 1.67e-06
R10 N09 N10 4.74e-02
L11 N10 N11 2.72e-11
R11 N10 N11 1.05e-01
L12 N11 N12 3.50e-11
R12 N11 N12 4.56e-02
C13 N12 N13 4.42e-07
L13 N12 N13 3.02e-12
R13 N12 N13 8.41e-03
C14 N13 N14 5.54e-08
L14 N13 N14 1.23e-11
R14 N13 N14 2.11e-02
C15 N14 Port2 1.49e-11
L15 N14 Port2 1.69e-11
R15 N14 Port2 6.90e-01
.ENDS GRM033R61C273KE84

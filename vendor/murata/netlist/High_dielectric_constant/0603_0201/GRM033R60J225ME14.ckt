*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRM033R60J225ME14
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM033R60J225ME14 Port1 Port2
C01 Port1 N01 1.96e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.29e-10
R03 N02 N03 8.63e-03
C04 N03 N04 1.05e-04
R04 N03 N04 3.05e+01
C05 N04 N05 1.55e-04
R05 N04 N05 4.55e+00
C06 N05 N06 1.50e-04
R06 N05 N06 8.31e-01
C07 N06 N07 1.71e-04
R07 N06 N07 1.42e-01
C08 N07 N08 1.51e-04
R08 N07 N08 2.99e-02
C09 N08 N09 9.51e-05
R09 N08 N09 6.80e-03
L10 N09 N10 3.48e-11
R10 N09 N10 1.94e-01
L11 N10 N11 6.69e-11
R11 N10 N11 3.03e-02
L12 N11 N12 7.93e-11
R12 N11 N12 1.01e-02
C13 N12 N13 2.58e-05
L13 N12 N13 6.10e-12
R13 N12 N13 1.22e-03
C14 N13 Port2 3.49e-06
L14 N13 Port2 1.63e-11
R14 N13 Port2 2.63e-03
.ENDS GRM033R60J225ME14

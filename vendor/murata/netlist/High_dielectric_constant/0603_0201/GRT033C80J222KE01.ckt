*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/2.20e-03[uF]/6.3[V]
* Murata P/N :GRT033C80J222KE01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C80J222KE01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+09
L02 N01 N02 1.74e-10
R03 N02 N03 1.54e-01
C04 N03 N04 2.47e-07
R04 N03 N04 1.20e+04
C05 N04 N05 3.04e-07
R05 N04 N05 1.25e+03
C06 N05 N06 3.28e-07
R06 N05 N06 1.22e+02
C07 N06 N07 2.53e-07
R07 N06 N07 1.99e+01
C08 N07 N08 1.68e-07
R08 N07 N08 3.33e+00
C09 N08 N09 1.41e-07
R09 N08 N09 3.90e-01
C10 N09 N10 1.19e-07
R10 N09 N10 8.96e-02
L11 N10 N11 2.37e-11
R11 N10 N11 3.35e-01
C12 N11 N12 2.39e-09
L12 N11 N12 1.36e-11
R12 N11 N12 8.28e-02
C13 N12 Port2 3.62e-12
L13 N12 Port2 5.74e-11
R13 N12 Port2 1.07e+01
.ENDS GRT033C80J222KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/6.80e-02[uF]/10[V]
* Murata P/N :GRT033R61A683KE01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R61A683KE01 Port1 Port2
C01 Port1 N01 6.70e-08
R01 Port1 N01 7.35e+08
L02 N01 N02 1.82e-10
R03 N02 N03 3.79e-02
C04 N03 N04 4.86e-06
R04 N03 N04 7.60e+02
C05 N04 N05 6.67e-06
R05 N04 N05 9.35e+01
C06 N05 N06 8.73e-06
R06 N05 N06 1.20e+01
C07 N06 N07 9.18e-06
R07 N06 N07 1.78e+00
C08 N07 N08 9.37e-06
R08 N07 N08 2.66e-01
C09 N08 N09 7.11e-06
R09 N08 N09 5.30e-02
C10 N09 N10 5.90e-06
R10 N09 N10 1.33e-02
L11 N10 N11 2.55e-11
R11 N10 N11 1.80e-01
L12 N11 N12 4.04e-11
R12 N11 N12 7.18e-02
C13 N12 N13 5.80e-08
L13 N12 N13 2.68e-11
R13 N12 N13 1.88e-02
C14 N13 Port2 2.84e-11
L14 N13 Port2 1.49e-11
R14 N13 Port2 7.03e-01
.ENDS GRT033R61A683KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/3.30e-01[uF]/6.3[V]
* Murata P/N :GRT033R60J334ME01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033R60J334ME01 Port1 Port2
C01 Port1 N01 2.69e-07
R01 Port1 N01 1.52e+08
L02 N01 N02 1.06e-10
R03 N02 N03 2.01e-02
C04 N03 N04 1.47e-05
R04 N03 N04 2.87e+02
C05 N04 N05 1.94e-05
R05 N04 N05 2.39e+01
C06 N05 N06 2.36e-05
R06 N05 N06 2.08e+00
C07 N06 N07 2.20e-05
R07 N06 N07 2.18e-01
C08 N07 N08 1.61e-05
R08 N07 N08 2.81e-02
L09 N08 N09 2.23e-11
R09 N08 N09 1.76e-01
L10 N09 N10 6.49e-11
R10 N09 N10 5.90e-02
C11 N10 N11 2.47e-07
L11 N10 N11 4.59e-11
R11 N10 N11 6.18e-03
C12 N11 Port2 2.03e-12
L12 N11 Port2 7.84e-11
R12 N11 Port2 2.20e+01
.ENDS GRT033R60J334ME01

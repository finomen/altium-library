*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X5R(-55to85[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GRJ033R61A105ME11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ033R61A105ME11 Port1 Port2
C01 Port1 N01 7.54e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.52e-10
R03 N02 N03 3.98e-02
C04 N03 N04 3.34e-05
R04 N03 N04 6.55e+01
C05 N04 N05 5.92e-05
R05 N04 N05 3.93e+00
C06 N05 N06 6.42e-05
R06 N05 N06 6.17e-01
C07 N06 N07 6.69e-05
R07 N06 N07 1.13e-01
C08 N07 N08 4.81e-05
R08 N07 N08 2.71e-02
C09 N08 N09 3.29e-05
R09 N08 N09 6.96e-03
L10 N09 N10 1.60e-11
R10 N09 N10 1.26e-01
L11 N10 N11 3.05e-11
R11 N10 N11 5.75e-02
L12 N11 N12 1.15e-10
R12 N11 N12 2.68e-02
C13 N12 Port2 3.75e-06
L13 N12 Port2 1.19e-11
R13 N12 Port2 2.79e-03
.ENDS GRJ033R61A105ME11

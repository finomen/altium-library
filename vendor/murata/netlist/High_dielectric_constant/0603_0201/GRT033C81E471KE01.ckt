*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X6S(-55to105[deg])/4.70e-04[uF]/25[V]
* Murata P/N :GRT033C81E471KE01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT033C81E471KE01 Port1 Port2
C01 Port1 N01 4.94e-10
R01 Port1 N01 1.00e+09
L02 N01 N02 2.16e-10
R03 N02 N03 2.80e-01
C04 N03 N04 4.27e-08
R04 N03 N04 5.15e+04
C05 N04 N05 9.73e-08
R05 N04 N05 5.52e+03
C06 N05 N06 7.16e-08
R06 N05 N06 8.75e+02
C07 N06 N07 5.87e-08
R07 N06 N07 1.05e+02
C08 N07 N08 4.05e-08
R08 N07 N08 1.52e+01
C09 N08 N09 2.97e-08
R09 N08 N09 2.23e+00
C10 N09 N10 1.78e-08
R10 N09 N10 4.06e-01
C11 N10 N11 2.65e-09
R11 N10 N11 1.50e-01
C12 N11 N12 2.04e-08
R12 N11 N12 1.30e-01
L13 N12 N13 5.89e-11
R13 N12 N13 7.93e-01
C14 N13 Port2 9.33e-12
L14 N13 Port2 3.21e-11
R14 N13 Port2 5.97e+00
.ENDS GRT033C81E471KE01

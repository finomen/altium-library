*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-02[uF]/16[V]
* Murata P/N :GCJ188R71C823KA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C823KA01 Port1 Port2
C01 Port1 N01 8.26e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 1.31e-10
R03 N02 N03 9.78e-02
C04 N03 N04 1.67e-05
R04 N03 N04 2.38e+02
C05 N04 N05 1.26e-05
R05 N04 N05 9.69e+01
C06 N05 N06 1.03e-05
R06 N05 N06 1.11e+01
C07 N06 N07 9.50e-06
R07 N06 N07 1.31e+00
C08 N07 N08 1.01e-05
R08 N07 N08 1.34e-01
C09 N08 N09 5.22e-06
R09 N08 N09 1.90e-02
L10 N09 N10 9.30e-11
R10 N09 N10 6.17e-02
C11 N10 N11 5.90e-07
L11 N10 N11 1.83e-11
R11 N10 N11 1.43e-02
C12 N11 N12 1.67e-07
L12 N11 N12 2.79e-11
R12 N11 N12 2.81e-02
C13 N12 N13 3.16e-11
L13 N12 N13 1.71e-10
R13 N12 N13 2.03e+00
C14 N13 Port2 1.07e-12
L14 N13 Port2 1.80e-10
R14 N13 Port2 2.75e+01
.ENDS GCJ188R71C823KA01

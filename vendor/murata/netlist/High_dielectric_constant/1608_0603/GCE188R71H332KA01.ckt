*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCE188R71H332KA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H332KA01 Port1 Port2
C01 Port1 N01 3.31e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 2.29e-01
C04 N03 N04 3.54e-07
R04 N03 N04 7.06e+03
C05 N04 N05 5.59e-07
R05 N04 N05 3.79e+02
C06 N05 N06 5.48e-07
R06 N05 N06 4.56e+01
C07 N06 N07 4.12e-07
R07 N06 N07 7.23e+00
C08 N07 N08 1.74e-07
R08 N07 N08 1.35e+00
C09 N08 N09 9.95e-08
R09 N08 N09 1.94e-01
L10 N09 N10 1.41e-10
R10 N09 N10 2.77e+00
C11 N10 N11 3.13e-08
L11 N10 N11 8.77e-12
R11 N10 N11 4.92e-02
C12 N11 N12 3.35e-09
L12 N11 N12 2.97e-11
R12 N11 N12 1.56e-01
C13 N12 N13 2.91e-11
L13 N12 N13 9.92e-11
R13 N12 N13 1.96e+00
C14 N13 Port2 4.00e-12
L14 N13 Port2 8.72e-11
R14 N13 Port2 2.75e+01
.ENDS GCE188R71H332KA01

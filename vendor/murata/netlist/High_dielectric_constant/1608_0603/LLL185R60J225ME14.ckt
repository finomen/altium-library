*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X5R(-55to85[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :LLL185R60J225ME14
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R60J225ME14 Port1 Port2
C01 Port1 N01 1.58e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 5.17e-11
R03 N02 N03 3.43e-03
C04 N03 N04 4.40e-05
R04 N03 N04 3.11e+01
C05 N04 N05 5.17e-05
R05 N04 N05 3.14e+00
C06 N05 N06 5.02e-05
R06 N05 N06 4.21e-01
C07 N06 N07 4.35e-05
R07 N06 N07 6.50e-02
C08 N07 N08 3.47e-05
R08 N07 N08 1.28e-02
C09 N08 N09 4.75e-05
R09 N08 N09 1.69e-03
L10 N09 N10 1.31e-11
R10 N09 N10 1.61e-01
L11 N10 N11 9.86e-12
R11 N10 N11 2.39e-02
L12 N11 N12 6.73e-11
R12 N11 N12 1.84e-02
C13 N12 N13 2.42e-06
L13 N12 N13 2.80e-11
R13 N12 N13 1.02e-02
C14 N13 N14 1.39e-06
L14 N13 N14 1.76e-11
R14 N13 N14 8.84e-03
C15 N14 Port2 1.09e-10
L15 N14 Port2 2.68e-12
R15 N14 Port2 6.54e-01
.ENDS LLL185R60J225ME14

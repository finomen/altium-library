*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/2.20e-02[uF]/16[V]
* Murata P/N :LLL185R71C223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71C223MA01 Port1 Port2
C01 Port1 N01 2.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.53e-11
R03 N02 N03 2.24e-02
C04 N03 N04 2.19e-06
R04 N03 N04 1.81e+03
C05 N04 N05 3.39e-06
R05 N04 N05 1.47e+02
C06 N05 N06 2.63e-06
R06 N05 N06 2.56e+01
C07 N06 N07 2.72e-06
R07 N06 N07 2.87e+00
C08 N07 N08 2.49e-06
R08 N07 N08 4.96e-01
C09 N08 N09 1.73e-06
R09 N08 N09 1.08e-01
C10 N09 N10 1.07e-06
R10 N09 N10 2.28e-02
L11 N10 N11 1.96e-11
R11 N10 N11 6.27e-02
C12 N11 N12 7.74e-08
L12 N11 N12 4.07e-12
R12 N11 N12 1.55e-02
C13 N12 N13 1.19e-08
L13 N12 N13 6.42e-12
R13 N12 N13 2.48e-02
C14 N13 Port2 5.24e-12
L14 N13 Port2 7.06e-11
R14 N13 Port2 1.04e+01
.ENDS LLL185R71C223MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E473KA01 Port1 Port2
C01 Port1 N01 4.98e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.01e-10
R03 N02 N03 2.58e-02
C04 N03 N04 6.68e-06
R04 N03 N04 5.92e+02
C05 N04 N05 1.10e-05
R05 N04 N05 7.12e+01
C06 N05 N06 6.67e-06
R06 N05 N06 1.83e+01
C07 N06 N07 7.53e-06
R07 N06 N07 1.92e+00
C08 N07 N08 5.07e-06
R08 N07 N08 4.27e-01
C09 N08 N09 2.83e-06
R09 N08 N09 7.63e-02
C10 N09 N10 3.43e-06
R10 N09 N10 9.87e-03
L11 N10 N11 1.58e-10
R11 N10 N11 1.28e-01
L12 N11 N12 4.41e-12
R12 N11 N12 4.68e-02
C13 N12 N13 3.10e-07
L13 N12 N13 2.23e-11
R13 N12 N13 3.09e-02
C14 N13 N14 1.02e-07
L14 N13 N14 3.47e-11
R14 N13 N14 5.60e-02
C15 N14 Port2 2.54e-12
L15 N14 Port2 1.48e-10
R15 N14 Port2 3.05e+01
.ENDS GCE188R71E473KA01

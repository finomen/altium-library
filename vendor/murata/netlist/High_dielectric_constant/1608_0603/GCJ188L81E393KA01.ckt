*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCJ188L81E393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E393KA01 Port1 Port2
C01 Port1 N01 3.97e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 2.73e-02
C04 N03 N04 4.76e-06
R04 N03 N04 1.51e+03
C05 N04 N05 5.69e-06
R05 N04 N05 1.18e+02
C06 N05 N06 5.71e-06
R06 N05 N06 1.18e+01
C07 N06 N07 4.62e-06
R07 N06 N07 1.45e+00
C08 N07 N08 3.60e-06
R08 N07 N08 1.87e-01
C09 N08 N09 2.55e-06
R09 N08 N09 2.96e-02
L10 N09 N10 1.25e-10
R10 N09 N10 1.20e-01
C11 N10 N11 2.15e-07
L11 N10 N11 2.11e-11
R11 N10 N11 2.80e-02
C12 N11 N12 6.67e-08
L12 N11 N12 2.91e-11
R12 N11 N12 4.14e-02
C13 N12 N13 3.99e-12
L13 N12 N13 1.15e-10
R13 N12 N13 1.44e+01
C14 N13 Port2 4.03e-12
L14 N13 Port2 6.46e-11
R14 N13 Port2 2.01e+01
.ENDS GCJ188L81E393KA01

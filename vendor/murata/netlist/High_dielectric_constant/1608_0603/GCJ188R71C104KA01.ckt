*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/16[V]
* Murata P/N :GCJ188R71C104KA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C104KA01 Port1 Port2
C01 Port1 N01 9.62e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.47e-10
R03 N02 N03 2.36e-02
C04 N03 N04 1.12e-05
R04 N03 N04 1.10e+02
C05 N04 N05 1.37e-05
R05 N04 N05 1.36e+01
C06 N05 N06 1.26e-05
R06 N05 N06 2.30e+00
C07 N06 N07 1.25e-05
R07 N06 N07 3.65e-01
C08 N07 N08 9.65e-06
R08 N07 N08 8.26e-02
C09 N08 N09 5.89e-06
R09 N08 N09 2.10e-02
L10 N09 N10 1.06e-10
R10 N09 N10 9.36e-02
C11 N10 N11 1.10e-06
L11 N10 N11 1.28e-11
R11 N10 N11 1.24e-02
C12 N11 N12 1.26e-07
L12 N11 N12 5.22e-11
R12 N11 N12 3.56e-02
C13 N12 N13 8.59e-11
L13 N12 N13 6.90e-11
R13 N12 N13 8.30e-01
C14 N13 Port2 2.08e-12
L14 N13 Port2 1.57e-10
R14 N13 Port2 2.09e+01
.ENDS GCJ188R71C104KA01

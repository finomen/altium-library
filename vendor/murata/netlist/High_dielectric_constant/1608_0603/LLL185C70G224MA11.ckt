*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7S(-55to125[deg])/2.20e-01[uF]/4[V]
* Murata P/N :LLL185C70G224MA11
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185C70G224MA11 Port1 Port2
C01 Port1 N01 2.05e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 3.16e-11
R03 N02 N03 8.25e-03
C04 N03 N04 2.20e-05
R04 N03 N04 1.81e+02
C05 N04 N05 3.83e-05
R05 N04 N05 2.03e+01
C06 N05 N06 2.30e-05
R06 N05 N06 6.57e+00
C07 N06 N07 1.88e-05
R07 N06 N07 8.29e-01
C08 N07 N08 1.94e-05
R08 N07 N08 9.86e-02
C09 N08 N09 1.46e-05
R09 N08 N09 2.16e-02
C10 N09 N10 1.01e-05
R10 N09 N10 4.52e-03
L11 N10 N11 7.25e-12
R11 N10 N11 6.07e-02
L12 N11 N12 3.13e-11
R12 N11 N12 2.82e-02
C13 N12 N13 4.41e-07
L13 N12 N13 7.25e-12
R13 N12 N13 5.93e-03
C14 N13 Port2 4.36e-12
L14 N13 Port2 6.69e-11
R14 N13 Port2 1.28e+01
.ENDS LLL185C70G224MA11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7S(-55to125[deg])/2.20e+00[uF]/4[V]
* Murata P/N :LLL185C70G225ME01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185C70G225ME01 Port1 Port2
C01 Port1 N01 1.72e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 5.23e-11
R03 N02 N03 3.39e-03
C04 N03 N04 2.38e-05
R04 N03 N04 2.13e+02
C05 N04 N05 4.32e-05
R05 N04 N05 9.07e+00
C06 N05 N06 4.06e-05
R06 N05 N06 9.99e-01
C07 N06 N07 3.49e-05
R07 N06 N07 1.18e-01
C08 N07 N08 3.30e-05
R08 N07 N08 1.33e-02
C09 N08 N09 4.85e-05
R09 N08 N09 2.85e-03
L10 N09 N10 1.28e-11
R10 N09 N10 1.61e-01
L11 N10 N11 9.37e-12
R11 N10 N11 3.12e-02
L12 N11 N12 6.63e-11
R12 N11 N12 2.02e-02
C13 N12 N13 3.11e-06
L13 N12 N13 2.08e-11
R13 N12 N13 8.55e-03
C14 N13 N14 1.00e-06
L14 N13 N14 2.45e-11
R14 N13 N14 8.87e-03
C15 N14 Port2 1.29e-10
L15 N14 Port2 2.64e-12
R15 N14 Port2 3.50e-01
.ENDS LLL185C70G225ME01

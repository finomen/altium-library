*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCD188R72A822MA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R72A822MA01 Port1 Port2
C01 Port1 N01 8.79e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.83e-11
R03 N02 N03 4.42e-02
C04 N03 N04 1.14e-06
R04 N03 N04 1.94e+03
C05 N04 N05 2.05e-06
R05 N04 N05 2.44e+02
C06 N05 N06 1.24e-06
R06 N05 N06 5.98e+01
C07 N06 N07 1.71e-06
R07 N06 N07 7.71e+00
C08 N07 N08 9.23e-07
R08 N07 N08 2.27e+00
C09 N08 N09 2.16e-06
R09 N08 N09 2.32e-01
C10 N09 N10 7.27e-07
R10 N09 N10 2.15e-01
C11 N10 N11 4.77e-07
R11 N10 N11 5.05e-02
L12 N11 N12 8.19e-11
R12 N11 N12 2.04e-01
C13 N12 N13 5.83e-08
L13 N12 N13 1.68e-11
R13 N12 N13 5.97e-02
C14 N13 N14 1.36e-08
L14 N13 N14 3.18e-11
R14 N13 N14 1.16e-01
C15 N14 N15 6.67e-12
L15 N14 N15 1.19e-10
R15 N14 N15 1.84e+01
C16 N15 Port2 1.32e-12
L16 N15 Port2 1.99e-10
R16 N15 Port2 4.98e+01
.ENDS GCD188R72A822MA01

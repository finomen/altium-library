*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCJ188R92A272KA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A272KA01 Port1 Port2
C01 Port1 N01 2.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 6.47e-02
C04 N03 N04 1.34e-07
R04 N03 N04 3.84e+04
C05 N04 N05 1.64e-07
R05 N04 N05 3.35e+03
C06 N05 N06 1.52e-07
R06 N05 N06 3.84e+02
C07 N06 N07 1.24e-07
R07 N06 N07 5.68e+01
C08 N07 N08 8.90e-08
R08 N07 N08 7.18e+00
C09 N08 N09 5.90e-08
R09 N08 N09 8.83e-01
C10 N09 N10 4.94e-08
R10 N09 N10 1.23e-01
L11 N10 N11 9.06e-11
R11 N10 N11 4.27e-01
C12 N11 N12 1.60e-08
L12 N11 N12 1.46e-11
R12 N11 N12 1.46e-01
C13 N12 N13 5.21e-09
L13 N12 N13 1.83e-11
R13 N12 N13 2.12e-01
C14 N13 Port2 1.99e-12
L14 N13 Port2 1.82e-10
R14 N13 Port2 4.13e+01
.ENDS GCJ188R92A272KA01

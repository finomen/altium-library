*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/5.60e-03[uF]/100[V]
* Murata P/N :GCJ188R92A562KA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A562KA01 Port1 Port2
C01 Port1 N01 5.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.42e-10
R03 N02 N03 5.91e-02
C04 N03 N04 3.48e-07
R04 N03 N04 9.42e+03
C05 N04 N05 3.95e-07
R05 N04 N05 1.36e+03
C06 N05 N06 3.08e-07
R06 N05 N06 1.75e+02
C07 N06 N07 2.61e-07
R07 N06 N07 2.60e+01
C08 N07 N08 1.99e-07
R08 N07 N08 3.97e+00
C09 N08 N09 1.36e-07
R09 N08 N09 6.04e-01
C10 N09 N10 1.23e-07
R10 N09 N10 6.99e-02
L11 N10 N11 7.62e-11
R11 N10 N11 3.57e-01
C12 N11 N12 2.88e-08
L12 N11 N12 1.59e-11
R12 N11 N12 1.01e-01
C13 N12 N13 5.31e-09
L13 N12 N13 3.49e-11
R13 N12 N13 1.59e-01
C14 N13 Port2 4.29e-12
L14 N13 Port2 8.04e-11
R14 N13 Port2 1.38e+01
.ENDS GCJ188R92A562KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCJ188R71H472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H472KA01 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 1.97e-01
C04 N03 N04 4.44e-07
R04 N03 N04 7.73e+03
C05 N04 N05 7.28e-07
R05 N04 N05 3.22e+02
C06 N05 N06 7.02e-07
R06 N05 N06 2.68e+01
C07 N06 N07 5.24e-07
R07 N06 N07 3.08e+00
C08 N07 N08 3.35e-07
R08 N07 N08 5.53e-01
C09 N08 N09 1.56e-07
R09 N08 N09 1.19e-01
L10 N09 N10 1.05e-10
R10 N09 N10 3.63e-01
C11 N10 N11 2.78e-08
L11 N10 N11 1.69e-11
R11 N10 N11 6.93e-02
C12 N11 N12 9.09e-09
L12 N11 N12 2.16e-11
R12 N11 N12 1.17e-01
C13 N12 N13 5.33e-11
L13 N12 N13 4.75e-11
R13 N12 N13 9.94e-01
C14 N13 Port2 2.21e-12
L14 N13 Port2 1.09e-10
R14 N13 Port2 9.40e+00
.ENDS GCJ188R71H472KA01

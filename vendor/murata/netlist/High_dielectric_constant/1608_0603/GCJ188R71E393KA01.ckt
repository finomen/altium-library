*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCJ188R71E393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E393KA01 Port1 Port2
C01 Port1 N01 3.91e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 4.28e-02
C04 N03 N04 4.37e-06
R04 N03 N04 6.19e+02
C05 N04 N05 5.05e-06
R05 N04 N05 5.65e+01
C06 N05 N06 5.15e-06
R06 N05 N06 7.98e+00
C07 N06 N07 4.81e-06
R07 N06 N07 1.18e+00
C08 N07 N08 3.61e-06
R08 N07 N08 2.24e-01
C09 N08 N09 2.08e-06
R09 N08 N09 5.00e-02
L10 N09 N10 8.83e-11
R10 N09 N10 1.16e-01
C11 N10 N11 2.99e-07
L11 N10 N11 1.51e-11
R11 N10 N11 1.59e-02
C12 N11 N12 5.13e-08
L12 N11 N12 3.91e-11
R12 N11 N12 4.23e-02
C13 N12 N13 7.01e-11
L13 N12 N13 7.64e-11
R13 N12 N13 1.12e+00
C14 N13 Port2 1.80e-12
L14 N13 Port2 1.84e-10
R14 N13 Port2 2.86e+01
.ENDS GCJ188R71E393KA01

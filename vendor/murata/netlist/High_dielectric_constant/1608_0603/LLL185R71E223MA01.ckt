*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/2.20e-02[uF]/25[V]
* Murata P/N :LLL185R71E223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71E223MA01 Port1 Port2
C01 Port1 N01 2.15e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.27e-11
R03 N02 N03 1.99e-02
C04 N03 N04 2.06e-06
R04 N03 N04 1.79e+03
C05 N04 N05 3.24e-06
R05 N04 N05 1.33e+02
C06 N05 N06 2.98e-06
R06 N05 N06 1.96e+01
C07 N06 N07 2.81e-06
R07 N06 N07 2.84e+00
C08 N07 N08 2.33e-06
R08 N07 N08 5.29e-01
C09 N08 N09 1.74e-06
R09 N08 N09 1.07e-01
C10 N09 N10 1.21e-06
R10 N09 N10 2.02e-02
L11 N10 N11 2.05e-11
R11 N10 N11 1.17e-01
C12 N11 N12 3.73e-08
L12 N11 N12 1.00e-11
R12 N11 N12 3.39e-02
C13 N12 N13 1.12e-08
L13 N12 N13 9.07e-12
R13 N12 N13 3.74e-02
C14 N13 Port2 5.97e-12
L14 N13 Port2 5.65e-11
R14 N13 Port2 8.53e+00
.ENDS LLL185R71E223MA01

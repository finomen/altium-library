*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ188R71H154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H154KA01 Port1 Port2
C01 Port1 N01 1.51e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.28e-10
R03 N02 N03 4.05e-02
C04 N03 N04 2.01e-05
R04 N03 N04 7.94e+02
C05 N04 N05 2.90e-05
R05 N04 N05 4.57e+01
C06 N05 N06 3.07e-05
R06 N05 N06 4.07e+00
C07 N06 N07 2.77e-05
R07 N06 N07 4.16e-01
C08 N07 N08 1.61e-05
R08 N07 N08 4.84e-02
L09 N08 N09 1.66e-11
R09 N08 N09 9.43e-02
L10 N09 N10 1.32e-10
R10 N09 N10 6.78e-02
C11 N10 N11 4.42e-07
L11 N10 N11 3.53e-11
R11 N10 N11 1.29e-02
C12 N11 N12 2.51e-07
L12 N11 N12 3.01e-11
R12 N11 N12 2.11e-02
C13 N12 N13 7.08e-12
L13 N12 N13 1.11e-10
R13 N12 N13 1.41e+01
C14 N13 Port2 4.75e-12
L14 N13 Port2 7.13e-11
R14 N13 Port2 1.83e+01
.ENDS GCJ188R71H154KA01

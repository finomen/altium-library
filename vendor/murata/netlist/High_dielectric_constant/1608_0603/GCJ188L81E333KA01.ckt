*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCJ188L81E333KA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E333KA01 Port1 Port2
C01 Port1 N01 3.32e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.60e-10
R03 N02 N03 3.49e-02
C04 N03 N04 5.26e-06
R04 N03 N04 2.24e+02
C05 N04 N05 6.04e-06
R05 N04 N05 2.64e+01
C06 N05 N06 5.48e-06
R06 N05 N06 3.99e+00
C07 N06 N07 4.68e-06
R07 N06 N07 6.47e-01
C08 N07 N08 3.78e-06
R08 N07 N08 1.25e-01
C09 N08 N09 3.79e-06
R09 N08 N09 2.51e-02
L10 N09 N10 8.24e-11
R10 N09 N10 1.20e-01
L11 N10 N11 9.69e-12
R11 N10 N11 4.80e-02
C12 N11 N12 2.44e-07
L12 N11 N12 1.43e-11
R12 N11 N12 2.04e-02
C13 N12 N13 3.94e-08
L13 N12 N13 3.59e-11
R13 N12 N13 4.99e-02
C14 N13 N14 6.69e-12
L14 N13 N14 9.84e-11
R14 N13 N14 1.11e+01
C15 N14 Port2 9.05e-12
L15 N14 Port2 3.65e-11
R15 N14 Port2 7.91e+00
.ENDS GCJ188L81E333KA01

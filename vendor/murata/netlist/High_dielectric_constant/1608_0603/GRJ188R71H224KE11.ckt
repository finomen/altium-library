*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GRJ188R71H224KE11
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H224KE11 Port1 Port2
C01 Port1 N01 2.26e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.13e-10
R03 N02 N03 2.24e-02
C04 N03 N04 1.93e-05
R04 N03 N04 1.65e-01
C05 N04 N05 2.93e-05
R05 N04 N05 8.09e-03
L06 N05 N06 1.84e-11
R06 N05 N06 7.72e-02
L07 N06 N07 1.64e-10
R07 N06 N07 5.98e-02
C08 N07 N08 1.11e-06
L08 N07 N08 2.52e-11
R08 N07 N08 1.07e-02
C09 N08 N09 5.44e-07
L09 N08 N09 2.77e-11
R09 N08 N09 2.14e-02
C10 N09 N10 5.72e-12
L10 N09 N10 9.27e-11
R10 N09 N10 1.17e+01
C11 N10 Port2 1.48e-11
L11 N10 Port2 2.28e-11
R11 N10 Port2 1.55e+01
.ENDS GRJ188R71H224KE11

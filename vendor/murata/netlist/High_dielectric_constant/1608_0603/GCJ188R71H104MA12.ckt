*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/50[V]
* Murata P/N :GCJ188R71H104MA12
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H104MA12 Port1 Port2
C01 Port1 N01 9.81e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.83e-10
R03 N02 N03 3.79e-02
C04 N03 N04 1.25e-05
R04 N03 N04 3.17e+02
C05 N04 N05 2.00e-05
R05 N04 N05 2.89e+01
C06 N05 N06 1.43e-05
R06 N05 N06 5.91e+00
C07 N06 N07 1.28e-05
R07 N06 N07 7.43e-01
C08 N07 N08 1.02e-05
R08 N07 N08 1.18e-01
C09 N08 N09 8.93e-06
R09 N08 N09 2.45e-02
C10 N09 N10 1.76e-06
R10 N09 N10 8.88e-03
L11 N10 N11 2.43e-10
R11 N10 N11 9.74e-02
L12 N11 N12 2.13e-11
R12 N11 N12 8.75e-02
C13 N12 N13 8.35e-07
L13 N12 N13 1.62e-11
R13 N12 N13 2.24e-02
C14 N13 N14 3.50e-07
L14 N13 N14 1.95e-11
R14 N13 N14 2.67e-02
C15 N14 Port2 3.81e-12
L15 N14 Port2 9.28e-11
R15 N14 Port2 1.25e+01
.ENDS GCJ188R71H104MA12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ188R92A682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A682KA01 Port1 Port2
C01 Port1 N01 6.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 4.42e-02
C04 N03 N04 2.78e-07
R04 N03 N04 2.69e+04
C05 N04 N05 4.13e-07
R05 N04 N05 1.62e+03
C06 N05 N06 3.16e-07
R06 N05 N06 2.40e+02
C07 N06 N07 2.66e-07
R07 N06 N07 2.69e+01
C08 N07 N08 2.15e-07
R08 N07 N08 3.18e+00
C09 N08 N09 1.47e-07
R09 N08 N09 4.76e-01
C10 N09 N10 1.13e-07
R10 N09 N10 6.19e-02
L11 N10 N11 3.60e-11
R11 N10 N11 6.76e-01
L12 N11 N12 8.72e-11
R12 N11 N12 2.75e-01
C13 N12 N13 2.75e-08
L13 N12 N13 2.27e-11
R13 N12 N13 1.41e-01
C14 N13 N14 9.87e-09
L14 N13 N14 2.76e-11
R14 N13 N14 1.54e-01
C15 N14 Port2 6.57e-12
L15 N14 Port2 4.90e-11
R15 N14 Port2 6.00e+00
.ENDS GCJ188R92A682KA01

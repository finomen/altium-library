*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/25[V]
* Murata P/N :GCE188R71E333MA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 3.18e-02
C04 N03 N04 3.77e-06
R04 N03 N04 9.80e+02
C05 N04 N05 7.98e-06
R05 N04 N05 8.94e+01
C06 N05 N06 5.12e-06
R06 N05 N06 2.76e+01
C07 N06 N07 4.87e-06
R07 N06 N07 4.48e+00
C08 N07 N08 3.66e-06
R08 N07 N08 8.70e-01
C09 N08 N09 2.22e-06
R09 N08 N09 1.64e-01
C10 N09 N10 1.92e-06
R10 N09 N10 2.56e-02
L11 N10 N11 1.06e-10
R11 N10 N11 1.25e-01
C12 N11 N12 4.84e-07
L12 N11 N12 8.35e-12
R12 N11 N12 1.33e-02
C13 N12 N13 3.76e-08
L13 N12 N13 4.84e-11
R13 N12 N13 6.35e-02
C14 N13 N14 5.10e-12
L14 N13 N14 1.36e-10
R14 N13 N14 1.93e+01
C15 N14 Port2 2.36e-12
L15 N14 Port2 1.51e-10
R15 N14 Port2 3.80e+01
.ENDS GCE188R71E333MA01

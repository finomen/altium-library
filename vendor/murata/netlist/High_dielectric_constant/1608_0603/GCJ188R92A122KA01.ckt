*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCJ188R92A122KA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A122KA01 Port1 Port2
C01 Port1 N01 1.19e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.92e-11
R03 N02 N03 1.21e-01
C04 N03 N04 6.91e-08
R04 N03 N04 5.04e+04
C05 N04 N05 1.18e-07
R05 N04 N05 6.80e+03
C06 N05 N06 6.96e-08
R06 N05 N06 1.59e+03
C07 N06 N07 5.88e-08
R07 N06 N07 1.87e+02
C08 N07 N08 4.80e-08
R08 N07 N08 2.97e+01
C09 N08 N09 3.74e-08
R09 N08 N09 4.76e+00
C10 N09 N10 2.39e-08
R10 N09 N10 8.31e-01
C11 N10 N11 1.60e-08
R11 N10 N11 1.22e-01
L12 N11 N12 5.54e-11
R12 N11 N12 7.70e-01
C13 N12 N13 1.61e-08
L13 N12 N13 3.39e-12
R13 N12 N13 4.65e-02
C14 N13 N14 1.44e-09
L14 N13 N14 1.34e-11
R14 N13 N14 2.10e-01
C15 N14 N15 2.30e-12
L15 N14 N15 2.63e-10
R15 N14 N15 6.11e+01
C16 N15 Port2 2.53e-12
L16 N15 Port2 1.15e-10
R16 N15 Port2 2.38e+01
.ENDS GCJ188R92A122KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.20e-01[uF]/50[V]
* Murata P/N :GCJ188R91H124KA01
* Property : C = 1.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H124KA01 Port1 Port2
C01 Port1 N01 1.13e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.19e-10
R03 N02 N03 2.18e-02
C04 N03 N04 4.95e-06
R04 N03 N04 1.70e+03
C05 N04 N05 5.52e-06
R05 N04 N05 1.48e+02
C06 N05 N06 4.44e-06
R06 N05 N06 1.82e+01
C07 N06 N07 3.91e-06
R07 N06 N07 2.09e+00
C08 N07 N08 2.64e-06
R08 N07 N08 2.72e-01
C09 N08 N09 2.45e-06
R09 N08 N09 2.83e-02
C10 N09 N10 5.05e-05
R10 N09 N10 2.39e-04
L11 N10 N11 9.44e-11
R11 N10 N11 8.57e-02
L12 N11 N12 1.17e-11
R12 N11 N12 8.38e-02
C13 N12 N13 1.61e-06
L13 N12 N13 6.68e-12
R13 N12 N13 7.51e-03
C14 N13 N14 9.51e-08
L14 N13 N14 4.61e-11
R14 N13 N14 3.36e-02
C15 N14 Port2 2.64e-12
L15 N14 Port2 1.95e-10
R15 N14 Port2 3.88e+01
.ENDS GCJ188R91H124KA01

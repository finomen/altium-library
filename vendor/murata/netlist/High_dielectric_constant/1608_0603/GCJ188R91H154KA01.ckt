*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-01[uF]/50[V]
* Murata P/N :GCJ188R91H154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H154KA01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.90e-10
R03 N02 N03 1.83e-02
C04 N03 N04 7.44e-06
R04 N03 N04 5.35e+02
C05 N04 N05 8.78e-06
R05 N04 N05 8.87e+01
C06 N05 N06 7.54e-06
R06 N05 N06 1.31e+01
C07 N06 N07 5.74e-06
R07 N06 N07 2.87e+00
C08 N07 N08 4.80e-06
R08 N07 N08 4.10e-01
C09 N08 N09 4.18e-06
R09 N08 N09 4.67e-02
C10 N09 N10 5.91e-06
R10 N09 N10 5.80e-03
L11 N10 N11 2.58e-11
R11 N10 N11 1.22e-01
L12 N11 N12 1.11e-10
R12 N11 N12 6.74e-02
C13 N12 N13 1.01e-06
L13 N12 N13 1.50e-11
R13 N12 N13 1.15e-02
C14 N13 N14 1.88e-07
L14 N13 N14 3.44e-11
R14 N13 N14 2.84e-02
C15 N14 Port2 2.63e-12
L15 N14 Port2 2.00e-10
R15 N14 Port2 4.38e+01
.ENDS GCJ188R91H154KA01

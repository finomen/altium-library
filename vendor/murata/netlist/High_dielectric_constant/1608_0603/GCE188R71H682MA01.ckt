*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCE188R71H682MA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H682MA01 Port1 Port2
C01 Port1 N01 6.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.46e-10
R03 N02 N03 6.90e-02
C04 N03 N04 9.03e-07
R04 N03 N04 1.92e+03
C05 N04 N05 1.04e-06
R05 N04 N05 2.05e+02
C06 N05 N06 9.32e-07
R06 N05 N06 2.30e+01
C07 N06 N07 7.69e-07
R07 N06 N07 3.20e+00
C08 N07 N08 4.79e-07
R08 N07 N08 5.81e-01
C09 N08 N09 3.82e-07
R09 N08 N09 7.87e-02
L10 N09 N10 7.15e-11
R10 N09 N10 2.40e-01
C11 N10 N11 5.75e-08
L11 N10 N11 1.18e-11
R11 N10 N11 5.00e-02
C12 N11 N12 1.09e-08
L12 N11 N12 2.56e-11
R12 N11 N12 1.22e-01
C13 N12 N13 6.66e-12
L13 N12 N13 1.05e-10
R13 N12 N13 1.41e+01
C14 N13 Port2 4.91e-12
L14 N13 Port2 6.54e-11
R14 N13 Port2 1.34e+01
.ENDS GCE188R71H682MA01

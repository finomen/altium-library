*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/50[V]
* Murata P/N :GCD188R71H103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H103MA01 Port1 Port2
C01 Port1 N01 9.88e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 3.86e-02
C04 N03 N04 1.17e-06
R04 N03 N04 3.15e+03
C05 N04 N05 1.95e-06
R05 N04 N05 2.56e+02
C06 N05 N06 1.83e-06
R06 N05 N06 5.35e+01
C07 N06 N07 1.32e-06
R07 N06 N07 9.67e+00
C08 N07 N08 9.79e-07
R08 N07 N08 1.38e+00
C09 N08 N09 7.04e-07
R09 N08 N09 1.97e-01
C10 N09 N10 6.21e-07
R10 N09 N10 4.04e-02
L11 N10 N11 1.11e-10
R11 N10 N11 2.30e-01
C12 N11 N12 7.01e-08
L12 N11 N12 1.67e-11
R12 N11 N12 6.52e-02
C13 N12 N13 1.74e-08
L13 N12 N13 3.09e-11
R13 N12 N13 1.16e-01
C14 N13 N14 6.45e-12
L14 N13 N14 9.43e-11
R14 N13 N14 1.27e+01
C15 N14 Port2 7.43e-12
L15 N14 Port2 5.32e-11
R15 N14 Port2 1.04e+01
.ENDS GCD188R71H103MA01

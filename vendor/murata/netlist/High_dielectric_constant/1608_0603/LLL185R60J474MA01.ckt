*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X5R(-55to85[deg])/4.70e-01[uF]/6.3[V]
* Murata P/N :LLL185R60J474MA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R60J474MA01 Port1 Port2
C01 Port1 N01 4.26e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 5.27e-11
R03 N02 N03 5.44e-03
C04 N03 N04 4.78e-05
R04 N03 N04 8.33e+01
C05 N04 N05 8.08e-05
R05 N04 N05 1.20e+01
C06 N05 N06 4.91e-05
R06 N05 N06 2.51e+00
C07 N06 N07 4.99e-05
R07 N06 N07 2.53e-01
C08 N07 N08 4.11e-05
R08 N07 N08 2.78e-02
C09 N08 N09 3.84e-05
R09 N08 N09 4.02e-03
L10 N09 N10 1.42e-11
R10 N09 N10 8.75e-02
L11 N10 N11 3.57e-11
R11 N10 N11 2.34e-02
C12 N11 N12 9.86e-07
L12 N11 N12 1.39e-11
R12 N11 N12 9.05e-03
C13 N12 N13 2.64e-07
L13 N12 N13 1.70e-11
R13 N12 N13 9.63e-03
C14 N13 Port2 1.89e-11
L14 N13 Port2 1.65e-11
R14 N13 Port2 2.21e+00
.ENDS LLL185R60J474MA01

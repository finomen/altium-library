*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCE188R71E393MA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E393MA01 Port1 Port2
C01 Port1 N01 4.15e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 2.98e-02
C04 N03 N04 4.91e-06
R04 N03 N04 7.53e+02
C05 N04 N05 8.32e-06
R05 N04 N05 6.71e+01
C06 N05 N06 7.18e-06
R06 N05 N06 1.44e+01
C07 N06 N07 6.46e-06
R07 N06 N07 3.29e+00
C08 N07 N08 4.56e-06
R08 N07 N08 6.11e-01
C09 N08 N09 3.92e-06
R09 N08 N09 1.23e-01
C10 N09 N10 2.06e-06
R10 N09 N10 3.54e-02
L11 N10 N11 1.39e-10
R11 N10 N11 1.32e-01
C12 N11 N12 2.89e-07
L12 N11 N12 1.97e-11
R12 N11 N12 2.60e-02
C13 N12 N13 7.21e-08
L13 N12 N13 3.58e-11
R13 N12 N13 5.52e-02
C14 N13 N14 5.71e-12
L14 N13 N14 9.60e-11
R14 N13 N14 1.60e+01
C15 N14 Port2 3.74e-12
L15 N14 Port2 9.11e-11
R15 N14 Port2 2.87e+01
.ENDS GCE188R71E393MA01

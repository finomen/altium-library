*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-01[uF]/16[V]
* Murata P/N :GCJ188R71C274KA01
* Property : C = 2.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C274KA01 Port1 Port2
C01 Port1 N01 2.67e-07
R01 Port1 N01 1.85e+09
L02 N01 N02 1.78e-10
R03 N02 N03 2.36e-02
C04 N03 N04 3.17e-05
R04 N03 N04 1.25e+02
C05 N04 N05 4.41e-05
R05 N04 N05 1.14e+01
C06 N05 N06 3.57e-05
R06 N05 N06 1.94e+00
C07 N06 N07 3.05e-05
R07 N06 N07 2.39e-01
C08 N07 N08 1.76e-05
R08 N07 N08 3.59e-02
L09 N08 N09 1.99e-11
R09 N08 N09 1.10e-01
L10 N09 N10 1.41e-10
R10 N09 N10 6.25e-02
C11 N10 N11 2.24e-06
L11 N10 N11 1.68e-11
R11 N10 N11 6.51e-03
C12 N11 N12 2.75e-07
L12 N11 N12 5.43e-11
R12 N11 N12 1.88e-02
C13 N12 N13 5.83e-12
L13 N12 N13 1.09e-10
R13 N12 N13 1.49e+01
C14 N13 Port2 4.39e-12
L14 N13 Port2 7.54e-11
R14 N13 Port2 2.73e+01
.ENDS GCJ188R71C274KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H122KA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H122KA01 Port1 Port2
C01 Port1 N01 1.25e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 2.96e-01
C04 N03 N04 1.03e-07
R04 N03 N04 2.80e+04
C05 N04 N05 1.91e-07
R05 N04 N05 1.44e+03
C06 N05 N06 2.11e-07
R06 N05 N06 1.61e+02
C07 N06 N07 1.97e-07
R07 N06 N07 2.54e+01
C08 N07 N08 1.23e-07
R08 N07 N08 5.15e+00
C09 N08 N09 5.31e-08
R09 N08 N09 1.18e+00
C10 N09 N10 1.96e-08
R10 N09 N10 2.70e-01
C11 N10 N11 4.67e-08
R11 N10 N11 7.83e-03
C12 N11 N12 1.08e-09
L12 N11 N12 1.51e-11
R12 N11 N12 1.44e-01
C13 N12 N13 1.26e-11
L13 N12 N13 2.54e-10
R13 N12 N13 5.37e+00
C14 N13 Port2 2.36e-12
L14 N13 Port2 1.31e-10
R14 N13 Port2 1.40e+01
.ENDS GCE188R71H122KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GRJ188R71C474ME11
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71C474ME11 Port1 Port2
C01 Port1 N01 4.13e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 1.45e-10
R03 N02 N03 3.44e-02
C04 N03 N04 2.24e-05
R04 N03 N04 8.93e-02
C05 N04 N05 3.47e-05
R05 N04 N05 4.30e-03
L06 N05 N06 2.29e-11
R06 N05 N06 1.26e-01
L07 N06 N07 1.40e-10
R07 N06 N07 5.69e-02
C08 N07 N08 8.54e-07
L08 N07 N08 6.63e-11
R08 N07 N08 1.00e-02
C09 N08 N09 5.64e-07
L09 N08 N09 4.03e-11
R09 N08 N09 1.31e-02
C10 N09 N10 6.03e-12
L10 N09 N10 8.59e-11
R10 N09 N10 1.33e+01
C11 N10 Port2 2.47e-12
L11 N10 Port2 1.09e-10
R11 N10 Port2 2.71e+01
.ENDS GRJ188R71C474ME11

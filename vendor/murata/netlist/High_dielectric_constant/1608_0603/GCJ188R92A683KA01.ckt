*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/6.80e-02[uF]/100[V]
* Murata P/N :GCJ188R92A683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A683KA01 Port1 Port2
C01 Port1 N01 6.49e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.79e-10
R03 N02 N03 4.22e-02
C04 N03 N04 3.46e-06
R04 N03 N04 2.08e+03
C05 N04 N05 4.11e-06
R05 N04 N05 1.99e+02
C06 N05 N06 3.24e-06
R06 N05 N06 2.50e+01
C07 N06 N07 2.88e-06
R07 N06 N07 2.87e+00
C08 N07 N08 1.96e-06
R08 N07 N08 4.95e-01
C09 N08 N09 1.23e-06
R09 N08 N09 6.12e-02
L10 N09 N10 2.18e-11
R10 N09 N10 1.48e-01
L11 N10 N11 1.17e-10
R11 N10 N11 1.00e-01
C12 N11 N12 3.12e-07
L12 N11 N12 2.32e-11
R12 N11 N12 2.59e-02
C13 N12 N13 1.05e-07
L13 N12 N13 3.05e-11
R13 N12 N13 4.27e-02
C14 N13 Port2 2.91e-12
L14 N13 Port2 1.37e-10
R14 N13 Port2 3.41e+01
.ENDS GCJ188R92A683KA01

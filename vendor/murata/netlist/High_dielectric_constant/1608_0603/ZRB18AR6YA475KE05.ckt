*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/35[V]
* Murata P/N :ZRB18AR6YA475KE05
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AR6YA475KE05 Port1 Port2
C01 Port1 N01 3.54e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 3.44e-10
R03 N02 N03 5.09e-03
C04 N03 N04 1.55e-04
R04 N03 N04 1.71e+01
C05 N04 N05 2.02e-04
R05 N04 N05 1.57e+00
C06 N05 N06 1.79e-04
R06 N05 N06 2.42e-01
C07 N06 N07 1.55e-04
R07 N06 N07 3.42e-02
C08 N07 N08 1.28e-04
R08 N07 N08 5.93e-03
L09 N08 N09 2.07e-11
R09 N08 N09 1.41e-01
L10 N09 N10 3.04e-11
R10 N09 N10 3.13e-02
L11 N10 N11 2.04e-10
R11 N10 N11 2.30e-02
C12 N11 N12 1.44e-05
L12 N11 N12 4.47e-11
R12 N11 N12 5.20e-03
C13 N12 N13 4.21e-06
L13 N12 N13 7.48e-11
R13 N12 N13 8.00e-03
C14 N13 Port2 3.63e-12
L14 N13 Port2 9.47e-11
R14 N13 Port2 2.82e+01
.ENDS ZRB18AR6YA475KE05

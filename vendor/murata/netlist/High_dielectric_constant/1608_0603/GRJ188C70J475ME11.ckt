*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188C70J475ME11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188C70J475ME11 Port1 Port2
C01 Port1 N01 3.48e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 2.04e-10
R03 N02 N03 7.60e-03
C04 N03 N04 1.57e-04
R04 N03 N04 2.45e+01
C05 N04 N05 2.00e-04
R05 N04 N05 2.10e+00
C06 N05 N06 1.99e-04
R06 N05 N06 3.24e-01
C07 N06 N07 2.13e-04
R07 N06 N07 5.16e-02
C08 N07 N08 1.65e-04
R08 N07 N08 1.26e-02
C09 N08 N09 8.56e-05
R09 N08 N09 3.97e-03
L10 N09 N10 2.50e-11
R10 N09 N10 1.22e-01
L11 N10 N11 4.32e-11
R11 N10 N11 2.67e-02
L12 N11 N12 2.85e-10
R12 N11 N12 2.13e-02
C13 N12 N13 1.44e-05
L13 N12 N13 4.70e-11
R13 N12 N13 4.74e-03
C14 N13 N14 7.93e-06
L14 N13 N14 4.14e-11
R14 N13 N14 5.50e-03
C15 N14 Port2 9.66e-12
L15 N14 Port2 4.08e-11
R15 N14 Port2 6.19e+00
.ENDS GRJ188C70J475ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCD188R71H562MA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H562MA01 Port1 Port2
C01 Port1 N01 5.74e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 6.16e-02
C04 N03 N04 7.02e-07
R04 N03 N04 2.70e+03
C05 N04 N05 8.61e-07
R05 N04 N05 2.89e+02
C06 N05 N06 7.23e-07
R06 N05 N06 3.25e+01
C07 N06 N07 5.35e-07
R07 N06 N07 4.04e+00
C08 N07 N08 4.34e-07
R08 N07 N08 6.14e-01
C09 N08 N09 5.36e-07
R09 N08 N09 6.68e-02
C10 N09 N10 4.54e-07
R10 N09 N10 3.68e-02
L11 N10 N11 6.54e-11
R11 N10 N11 1.65e-01
C12 N11 N12 1.81e-07
L12 N11 N12 3.03e-12
R12 N11 N12 2.86e-02
C13 N12 N13 9.67e-09
L13 N12 N13 2.24e-11
R13 N12 N13 1.07e-01
C14 N13 N14 5.67e-12
L14 N13 N14 1.76e-10
R14 N13 N14 2.06e+01
C15 N14 Port2 1.87e-12
L15 N14 Port2 1.76e-10
R15 N14 Port2 2.60e+01
.ENDS GCD188R71H562MA01

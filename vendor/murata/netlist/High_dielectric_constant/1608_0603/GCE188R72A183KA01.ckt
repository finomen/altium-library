*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCE188R72A183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A183KA01 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.00e-02
C04 N03 N04 2.60e-06
R04 N03 N04 1.53e+03
C05 N04 N05 3.51e-06
R05 N04 N05 2.06e+02
C06 N05 N06 2.61e-06
R06 N05 N06 3.42e+01
C07 N06 N07 2.48e-06
R07 N06 N07 3.93e+00
C08 N07 N08 2.06e-06
R08 N07 N08 5.40e-01
C09 N08 N09 1.69e-06
R09 N08 N09 1.17e-01
C10 N09 N10 1.59e-06
R10 N09 N10 3.29e-02
L11 N10 N11 1.09e-10
R11 N10 N11 1.86e-01
C12 N11 N12 1.14e-07
L12 N11 N12 2.03e-11
R12 N11 N12 5.52e-02
C13 N12 N13 2.80e-08
L13 N12 N13 3.89e-11
R13 N12 N13 9.99e-02
C14 N13 Port2 4.40e-12
L14 N13 Port2 8.64e-11
R14 N13 Port2 1.08e+01
.ENDS GCE188R72A183KA01

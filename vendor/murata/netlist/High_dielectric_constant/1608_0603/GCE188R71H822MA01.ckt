*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/8.20e-03[uF]/50[V]
* Murata P/N :GCE188R71H822MA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H822MA01 Port1 Port2
C01 Port1 N01 8.52e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 5.63e-02
C04 N03 N04 1.06e-06
R04 N03 N04 1.91e+03
C05 N04 N05 1.32e-06
R05 N04 N05 1.32e+02
C06 N05 N06 1.18e-06
R06 N05 N06 1.63e+01
C07 N06 N07 9.34e-07
R07 N06 N07 2.05e+00
C08 N07 N08 6.74e-07
R08 N07 N08 2.99e-01
C09 N08 N09 5.40e-07
R09 N08 N09 5.68e-02
L10 N09 N10 6.89e-11
R10 N09 N10 1.97e-01
C11 N10 N11 6.20e-08
L11 N10 N11 1.56e-11
R11 N10 N11 5.66e-02
C12 N11 N12 1.43e-08
L12 N11 N12 2.92e-11
R12 N11 N12 1.20e-01
C13 N12 N13 9.46e-09
L13 N12 N13 1.29e-11
R13 N12 N13 5.20e-02
C14 N13 N14 5.65e-12
L14 N13 N14 9.90e-11
R14 N13 N14 1.25e+01
C15 N14 Port2 4.58e-12
L15 N14 Port2 7.02e-11
R15 N14 Port2 1.66e+01
.ENDS GCE188R71H822MA01

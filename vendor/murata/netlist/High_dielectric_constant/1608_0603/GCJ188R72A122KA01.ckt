*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/100[V]
* Murata P/N :GCJ188R72A122KA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A122KA01 Port1 Port2
C01 Port1 N01 1.17e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-10
R03 N02 N03 2.40e-01
C04 N03 N04 9.19e-08
R04 N03 N04 9.70e+03
C05 N04 N05 1.35e-07
R05 N04 N05 4.05e+02
C06 N05 N06 1.44e-07
R06 N05 N06 4.44e+01
C07 N06 N07 1.20e-07
R07 N06 N07 7.44e+00
C08 N07 N08 7.25e-08
R08 N07 N08 2.10e+00
C09 N08 N09 4.55e-08
R09 N08 N09 5.36e-01
C10 N09 N10 2.44e-08
R10 N09 N10 1.44e-01
C11 N10 N11 1.90e-09
L11 N10 N11 1.08e-11
R11 N10 N11 1.45e-01
C12 N11 N12 1.42e-11
L12 N11 N12 2.51e-10
R12 N11 N12 5.47e+00
C13 N12 Port2 1.16e-12
L13 N12 Port2 2.38e-10
R13 N12 Port2 2.55e+01
.ENDS GCJ188R72A122KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCJ188R92A152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A152KA01 Port1 Port2
C01 Port1 N01 1.43e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.17e-01
C04 N03 N04 5.77e-08
R04 N03 N04 1.44e+05
C05 N04 N05 1.01e-07
R05 N04 N05 8.11e+03
C06 N05 N06 6.86e-08
R06 N05 N06 1.35e+03
C07 N06 N07 8.72e-08
R07 N06 N07 1.20e+02
C08 N07 N08 8.28e-08
R08 N07 N08 3.15e+01
C09 N08 N09 4.94e-08
R09 N08 N09 8.99e+00
C10 N09 N10 3.20e-08
R10 N09 N10 1.55e+00
C11 N10 N11 2.52e-08
R11 N10 N11 1.83e-01
C12 N11 N12 3.06e-07
R12 N11 N12 4.90e-02
L13 N12 N13 7.30e-11
R13 N12 N13 8.91e-01
C14 N13 N14 2.06e-08
L14 N13 N14 3.88e-12
R14 N13 N14 6.27e-02
C15 N14 N15 1.52e-09
L15 N14 N15 1.85e-11
R15 N14 N15 2.24e-01
C16 N15 N16 4.29e-12
L16 N15 N16 1.47e-10
R16 N15 N16 4.01e+01
C17 N16 Port2 4.51e-12
L17 N16 Port2 6.72e-11
R17 N16 Port2 2.92e+01
.ENDS GCJ188R92A152KA01

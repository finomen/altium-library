*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GCE188R71H223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H223MA01 Port1 Port2
C01 Port1 N01 2.09e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.43e-02
C04 N03 N04 2.39e-06
R04 N03 N04 1.43e+03
C05 N04 N05 5.53e-06
R05 N04 N05 1.31e+02
C06 N05 N06 4.21e-06
R06 N05 N06 3.36e+01
C07 N06 N07 3.83e-06
R07 N06 N07 9.05e+00
C08 N07 N08 2.36e-06
R08 N07 N08 1.72e+00
C09 N08 N09 1.33e-06
R09 N08 N09 3.07e-01
C10 N09 N10 1.32e-06
R10 N09 N10 3.53e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.09e-01
C12 N11 N12 9.74e-08
L12 N11 N12 2.62e-11
R12 N11 N12 5.64e-02
C13 N12 N13 2.72e-08
L13 N12 N13 4.42e-11
R13 N12 N13 9.63e-02
C14 N13 N14 5.72e-11
L14 N13 N14 9.79e-12
R14 N13 N14 4.03e+00
C15 N14 Port2 2.34e-12
L15 N14 Port2 1.33e-10
R15 N14 Port2 2.48e+01
.ENDS GCE188R71H223MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8M(-55to150[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GCJ188M8EC475KE08
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188M8EC475KE08 Port1 Port2
C01 Port1 N01 3.56e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.35e-10
R03 N02 N03 1.72e-02
C04 N03 N04 1.26e-04
R04 N03 N04 6.70e+01
C05 N04 N05 1.93e-04
R05 N04 N05 3.66e+00
C06 N05 N06 1.87e-04
R06 N05 N06 5.37e-01
C07 N06 N07 2.56e-04
R07 N06 N07 6.57e-02
C08 N07 N08 1.81e-04
R08 N07 N08 2.06e-02
C09 N08 N09 1.51e-04
R09 N08 N09 7.47e-03
L10 N09 N10 2.03e-11
R10 N09 N10 1.33e-01
L11 N10 N11 4.31e-11
R11 N10 N11 3.46e-02
L12 N11 N12 2.75e-10
R12 N11 N12 2.33e-02
C13 N12 N13 1.18e-05
L13 N12 N13 5.56e-11
R13 N12 N13 4.76e-03
C14 N13 N14 8.14e-06
L14 N13 N14 3.96e-11
R14 N13 N14 5.58e-03
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.19e-10
R15 N14 Port2 4.07e+01
.ENDS GCJ188M8EC475KE08

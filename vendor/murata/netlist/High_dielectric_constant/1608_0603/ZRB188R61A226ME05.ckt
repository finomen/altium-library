*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :ZRB188R61A226ME05
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB188R61A226ME05 Port1 Port2
C01 Port1 N01 1.79e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 2.98e-10
R03 N02 N03 3.07e-03
C04 N03 N04 1.08e-03
R04 N03 N04 4.91e+00
C05 N04 N05 1.36e-03
R05 N04 N05 6.12e-01
C06 N05 N06 1.37e-03
R06 N05 N06 9.60e-02
C07 N06 N07 1.59e-03
R07 N06 N07 1.39e-02
C08 N07 N08 9.25e-04
R08 N07 N08 2.16e-03
L09 N08 N09 3.68e-11
R09 N08 N09 8.76e-02
L10 N09 N10 9.03e-11
R10 N09 N10 2.42e-02
L11 N10 N11 2.83e-10
R11 N10 N11 1.04e-02
C12 N11 N12 5.65e-05
L12 N11 N12 7.08e-11
R12 N11 N12 1.48e-03
C13 N12 N13 2.19e-05
L13 N12 N13 8.40e-11
R13 N12 N13 2.47e-03
C14 N13 N14 1.14e-11
L14 N13 N14 4.85e-11
R14 N13 N14 3.35e+00
C15 N14 Port2 7.08e-12
L15 N14 Port2 3.07e-11
R15 N14 Port2 1.74e+01
.ENDS ZRB188R61A226ME05

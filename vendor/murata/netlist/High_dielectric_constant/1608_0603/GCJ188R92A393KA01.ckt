*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-02[uF]/100[V]
* Murata P/N :GCJ188R92A393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A393KA01 Port1 Port2
C01 Port1 N01 3.80e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.51e-10
R03 N02 N03 3.05e-02
C04 N03 N04 1.98e-06
R04 N03 N04 2.78e+03
C05 N04 N05 2.16e-06
R05 N04 N05 2.54e+02
C06 N05 N06 1.79e-06
R06 N05 N06 3.05e+01
C07 N06 N07 1.45e-06
R07 N06 N07 3.75e+00
C08 N07 N08 1.20e-06
R08 N07 N08 4.50e-01
C09 N08 N09 9.06e-07
R09 N08 N09 6.30e-02
L10 N09 N10 7.75e-11
R10 N09 N10 1.13e-01
L11 N10 N11 1.69e-11
R11 N10 N11 1.12e-01
C12 N11 N12 3.83e-07
L12 N11 N12 8.33e-12
R12 N11 N12 1.76e-02
C13 N12 N13 4.24e-08
L13 N12 N13 2.98e-11
R13 N12 N13 5.04e-02
C14 N13 Port2 3.24e-12
L14 N13 Port2 1.55e-10
R14 N13 Port2 3.84e+01
.ENDS GCJ188R92A393KA01

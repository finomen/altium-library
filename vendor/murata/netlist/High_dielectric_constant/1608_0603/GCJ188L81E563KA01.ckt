*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/5.60e-02[uF]/25[V]
* Murata P/N :GCJ188L81E563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E563KA01 Port1 Port2
C01 Port1 N01 5.41e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 1.42e-10
R03 N02 N03 3.81e-02
C04 N03 N04 7.20e-06
R04 N03 N04 1.24e+02
C05 N04 N05 8.87e-06
R05 N04 N05 9.83e+00
C06 N05 N06 7.09e-06
R06 N05 N06 1.15e+00
C07 N06 N07 7.83e-06
R07 N06 N07 1.06e-01
C08 N07 N08 5.26e-06
R08 N07 N08 4.62e-02
L09 N08 N09 9.38e-11
R09 N08 N09 1.16e-01
C10 N09 N10 3.84e-07
L10 N09 N10 1.58e-11
R10 N09 N10 1.72e-02
C11 N10 N11 5.77e-08
L11 N10 N11 4.46e-11
R11 N10 N11 4.56e-02
C12 N11 N12 8.29e-12
L12 N11 N12 8.33e-11
R12 N11 N12 1.64e+01
C13 N12 Port2 1.51e-12
L13 N12 Port2 1.79e-10
R13 N12 Port2 2.87e+01
.ENDS GCJ188L81E563KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GRJ188R71E105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E105KE11 Port1 Port2
C01 Port1 N01 7.52e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 2.12e-10
R03 N02 N03 1.54e-02
C04 N03 N04 8.11e-06
R04 N03 N04 7.17e+02
C05 N04 N05 4.11e-05
R05 N04 N05 1.75e+01
C06 N05 N06 2.33e-05
R06 N05 N06 5.06e+00
C07 N06 N07 2.04e-05
R07 N06 N07 5.64e-01
C08 N07 N08 1.42e-05
R08 N07 N08 9.33e-02
C09 N08 N09 1.17e-05
R09 N08 N09 1.11e-02
L10 N09 N10 3.50e-11
R10 N09 N10 1.17e-01
L11 N10 N11 2.16e-10
R11 N10 N11 4.56e-02
C12 N11 N12 4.45e-06
L12 N11 N12 2.30e-11
R12 N11 N12 7.82e-03
C13 N12 N13 1.53e-06
L13 N12 N13 3.38e-11
R13 N12 N13 1.36e-02
C14 N13 Port2 6.50e-12
L14 N13 Port2 7.56e-11
R14 N13 Port2 1.11e+01
.ENDS GRJ188R71E105KE11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GCE188R72A103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A103MA01 Port1 Port2
C01 Port1 N01 9.37e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 7.01e-02
C04 N03 N04 1.10e-06
R04 N03 N04 3.35e+03
C05 N04 N05 2.13e-06
R05 N04 N05 2.72e+02
C06 N05 N06 1.64e-06
R06 N05 N06 6.38e+01
C07 N06 N07 1.30e-06
R07 N06 N07 9.43e+00
C08 N07 N08 1.17e-06
R08 N07 N08 1.34e+00
C09 N08 N09 7.86e-07
R09 N08 N09 3.38e-01
C10 N09 N10 5.22e-07
R10 N09 N10 5.53e-02
L11 N10 N11 1.37e-10
R11 N10 N11 2.63e-01
C12 N11 N12 7.80e-08
L12 N11 N12 1.48e-11
R12 N11 N12 5.19e-02
C13 N12 N13 1.61e-08
L13 N12 N13 3.25e-11
R13 N12 N13 9.37e-02
C14 N13 N14 7.59e-12
L14 N13 N14 6.68e-11
R14 N13 N14 1.35e+01
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.46e-10
R15 N14 Port2 2.96e+01
.ENDS GCE188R72A103MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/16[V]
* Murata P/N :GCJ188L81C224KA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C224KA01 Port1 Port2
C01 Port1 N01 2.16e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 2.14e-10
R03 N02 N03 1.60e-02
C04 N03 N04 2.80e-05
R04 N03 N04 5.98e+01
C05 N04 N05 3.25e-05
R05 N04 N05 6.56e+00
C06 N05 N06 3.53e-05
R06 N05 N06 9.26e-01
C07 N06 N07 3.61e-05
R07 N06 N07 1.98e-01
C08 N07 N08 2.42e-05
R08 N07 N08 5.58e-02
C09 N08 N09 1.61e-05
R09 N08 N09 1.44e-02
L10 N09 N10 1.83e-11
R10 N09 N10 1.02e-01
L11 N10 N11 9.80e-11
R11 N10 N11 6.64e-02
C12 N11 N12 1.59e-06
L12 N11 N12 1.83e-11
R12 N11 N12 9.49e-03
C13 N12 N13 1.86e-07
L13 N12 N13 6.52e-11
R13 N12 N13 2.74e-02
C14 N13 Port2 3.14e-12
L14 N13 Port2 1.30e-10
R14 N13 Port2 2.50e+01
.ENDS GCJ188L81C224KA01

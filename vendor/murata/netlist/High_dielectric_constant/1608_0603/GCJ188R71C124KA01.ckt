*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-01[uF]/16[V]
* Murata P/N :GCJ188R71C124KA01
* Property : C = 1.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C124KA01 Port1 Port2
C01 Port1 N01 1.17e-07
R01 Port1 N01 4.17e+09
L02 N01 N02 2.03e-10
R03 N02 N03 5.93e-02
C04 N03 N04 1.21e-05
R04 N03 N04 5.97e+02
C05 N04 N05 1.44e-05
R05 N04 N05 4.63e+01
C06 N05 N06 1.54e-05
R06 N05 N06 4.32e+00
C07 N06 N07 1.15e-05
R07 N06 N07 6.11e-01
C08 N07 N08 8.09e-06
R08 N07 N08 8.58e-02
C09 N08 N09 1.09e-05
R09 N08 N09 7.87e-03
L10 N09 N10 1.10e-10
R10 N09 N10 8.54e-02
L11 N10 N11 1.17e-11
R11 N10 N11 7.30e-02
C12 N11 N12 5.21e-07
L12 N11 N12 2.46e-11
R12 N11 N12 1.41e-02
C13 N12 N13 1.54e-07
L13 N12 N13 3.45e-11
R13 N12 N13 2.66e-02
C14 N13 N14 6.67e-12
L14 N13 N14 9.77e-11
R14 N13 N14 1.40e+01
C15 N14 Port2 4.04e-12
L15 N14 Port2 8.39e-11
R15 N14 Port2 2.20e+01
.ENDS GCJ188R71C124KA01

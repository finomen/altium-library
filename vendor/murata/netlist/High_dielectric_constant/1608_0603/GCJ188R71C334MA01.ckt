*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-01[uF]/16[V]
* Murata P/N :GCJ188R71C334MA01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C334MA01 Port1 Port2
C01 Port1 N01 3.04e-07
R01 Port1 N01 1.52e+09
L02 N01 N02 2.24e-10
R03 N02 N03 1.92e-02
C04 N03 N04 3.33e-05
R04 N03 N04 1.20e+02
C05 N04 N05 4.52e-05
R05 N04 N05 1.28e+01
C06 N05 N06 4.11e-05
R06 N05 N06 1.77e+00
C07 N06 N07 3.24e-05
R07 N06 N07 2.23e-01
C08 N07 N08 2.27e-05
R08 N07 N08 2.86e-02
C09 N08 N09 2.93e-05
R09 N08 N09 4.67e-03
L10 N09 N10 2.52e-11
R10 N09 N10 1.14e-01
L11 N10 N11 1.64e-10
R11 N10 N11 5.67e-02
C12 N11 N12 2.43e-06
L12 N11 N12 1.79e-11
R12 N11 N12 7.31e-03
C13 N12 N13 4.47e-07
L13 N12 N13 4.52e-11
R13 N12 N13 1.83e-02
C14 N13 Port2 3.20e-12
L14 N13 Port2 1.14e-10
R14 N13 Port2 1.58e+01
.ENDS GCJ188R71C334MA01

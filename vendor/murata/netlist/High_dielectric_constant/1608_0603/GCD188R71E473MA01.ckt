*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCD188R71E473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71E473MA01 Port1 Port2
C01 Port1 N01 4.46e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.79e-10
R03 N02 N03 1.71e-02
C04 N03 N04 6.02e-06
R04 N03 N04 5.29e+02
C05 N04 N05 7.59e-06
R05 N04 N05 5.29e+01
C06 N05 N06 6.79e-06
R06 N05 N06 9.19e+00
C07 N06 N07 5.86e-06
R07 N06 N07 1.34e+00
C08 N07 N08 4.55e-06
R08 N07 N08 2.11e-01
C09 N08 N09 4.69e-06
R09 N08 N09 4.02e-02
C10 N09 N10 2.72e-06
R10 N09 N10 1.15e-02
L11 N10 N11 1.37e-10
R11 N10 N11 1.21e-01
C12 N11 N12 3.04e-07
L12 N11 N12 1.99e-11
R12 N11 N12 3.41e-02
C13 N12 N13 9.38e-08
L13 N12 N13 3.10e-11
R13 N12 N13 5.50e-02
C14 N13 N14 5.43e-12
L14 N13 N14 1.07e-10
R14 N13 N14 1.66e+01
C15 N14 Port2 4.30e-12
L15 N14 Port2 7.52e-11
R15 N14 Port2 1.44e+01
.ENDS GCD188R71E473MA01

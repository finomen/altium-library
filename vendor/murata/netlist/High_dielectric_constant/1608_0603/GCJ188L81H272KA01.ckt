*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.70e-03[uF]/50[V]
* Murata P/N :GCJ188L81H272KA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H272KA01 Port1 Port2
C01 Port1 N01 2.78e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-10
R03 N02 N03 1.57e-01
C04 N03 N04 4.07e-07
R04 N03 N04 6.74e+03
C05 N04 N05 8.37e-07
R05 N04 N05 4.77e+02
C06 N05 N06 6.66e-07
R06 N05 N06 1.58e+02
C07 N06 N07 5.75e-07
R07 N06 N07 4.16e+01
C08 N07 N08 3.73e-07
R08 N07 N08 7.92e+00
C09 N08 N09 2.32e-07
R09 N08 N09 1.29e+00
C10 N09 N10 1.25e-07
R10 N09 N10 2.61e-01
C11 N10 N11 5.84e-08
R11 N10 N11 8.11e-02
L12 N11 N12 4.17e-11
R12 N11 N12 2.02e-01
C13 N12 N13 2.63e-08
L13 N12 N13 9.19e-12
R13 N12 N13 6.16e-02
C14 N13 N14 3.53e-09
L14 N13 N14 2.74e-11
R14 N13 N14 1.60e-01
C15 N14 N15 1.68e-11
L15 N14 N15 1.17e-10
R15 N14 N15 2.53e+00
C16 N15 Port2 2.02e-12
L16 N15 Port2 1.89e-10
R16 N15 Port2 3.22e+01
.ENDS GCJ188L81H272KA01

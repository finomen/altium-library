*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/8.20e-02[uF]/25[V]
* Murata P/N :GCJ188L81E823KA01
* Property : C = 8.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E823KA01 Port1 Port2
C01 Port1 N01 7.98e-08
R01 Port1 N01 6.10e+09
L02 N01 N02 2.06e-10
R03 N02 N03 2.25e-02
C04 N03 N04 1.15e-05
R04 N03 N04 1.18e+02
C05 N04 N05 1.40e-05
R05 N04 N05 1.21e+01
C06 N05 N06 1.31e-05
R06 N05 N06 1.83e+00
C07 N06 N07 1.17e-05
R07 N06 N07 3.17e-01
C08 N07 N08 1.01e-05
R08 N07 N08 6.73e-02
C09 N08 N09 8.97e-06
R09 N08 N09 1.60e-02
L10 N09 N10 9.22e-11
R10 N09 N10 9.23e-02
L11 N10 N11 1.74e-11
R11 N10 N11 8.58e-02
C12 N11 N12 4.49e-07
L12 N11 N12 2.36e-11
R12 N11 N12 2.38e-02
C13 N12 N13 8.03e-08
L13 N12 N13 5.68e-11
R13 N12 N13 4.70e-02
C14 N13 Port2 4.05e-12
L14 N13 Port2 1.05e-10
R14 N13 Port2 1.85e+01
.ENDS GCJ188L81E823KA01

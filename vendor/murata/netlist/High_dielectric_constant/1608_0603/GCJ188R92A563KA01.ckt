*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/5.60e-02[uF]/100[V]
* Murata P/N :GCJ188R92A563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A563KA01 Port1 Port2
C01 Port1 N01 5.30e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.12e-10
R03 N02 N03 2.65e-02
C04 N03 N04 2.82e-06
R04 N03 N04 1.17e+03
C05 N04 N05 3.50e-06
R05 N04 N05 1.31e+02
C06 N05 N06 2.49e-06
R06 N05 N06 1.98e+01
C07 N06 N07 2.03e-06
R07 N06 N07 2.49e+00
C08 N07 N08 1.84e-06
R08 N07 N08 2.87e-01
C09 N08 N09 1.32e-06
R09 N08 N09 5.97e-02
L10 N09 N10 2.51e-11
R10 N09 N10 2.14e-01
L11 N10 N11 8.46e-11
R11 N10 N11 9.26e-02
C12 N11 N12 3.00e-07
L12 N11 N12 1.84e-11
R12 N11 N12 2.97e-02
C13 N12 N13 6.69e-08
L13 N12 N13 3.47e-11
R13 N12 N13 5.21e-02
C14 N13 Port2 3.22e-12
L14 N13 Port2 1.17e-10
R14 N13 Port2 3.19e+01
.ENDS GCJ188R92A563KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/25[V]
* Murata P/N :GCJ188R71E123KA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E123KA01 Port1 Port2
C01 Port1 N01 1.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.93e-01
C04 N03 N04 1.96e-06
R04 N03 N04 1.89e+03
C05 N04 N05 3.18e-06
R05 N04 N05 3.06e+02
C06 N05 N06 2.12e-06
R06 N05 N06 7.18e+01
C07 N06 N07 1.74e-06
R07 N06 N07 7.87e+00
C08 N07 N08 1.40e-06
R08 N07 N08 9.08e-01
C09 N08 N09 1.48e-06
R09 N08 N09 1.40e-01
C10 N09 N10 8.30e-07
R10 N09 N10 4.94e-02
L11 N10 N11 3.59e-11
R11 N10 N11 3.06e-01
L12 N11 N12 1.01e-10
R12 N11 N12 1.86e-01
C13 N12 N13 1.60e-07
L13 N12 N13 4.29e-12
R13 N12 N13 1.63e-02
C14 N13 N14 2.72e-07
L14 N13 N14 1.97e-12
R14 N13 N14 1.15e-02
C15 N14 Port2 1.84e-12
L15 N14 Port2 1.44e-10
R15 N14 Port2 2.43e+01
.ENDS GCJ188R71E123KA01

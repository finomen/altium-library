*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/50[V]
* Murata P/N :GCD188R71H183MA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H183MA01 Port1 Port2
C01 Port1 N01 1.85e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 2.63e-02
C04 N03 N04 2.45e-06
R04 N03 N04 1.61e+03
C05 N04 N05 3.18e-06
R05 N04 N05 1.61e+02
C06 N05 N06 3.49e-06
R06 N05 N06 2.79e+01
C07 N06 N07 3.04e-06
R07 N06 N07 4.53e+00
C08 N07 N08 2.12e-06
R08 N07 N08 1.11e+00
C09 N08 N09 1.24e-06
R09 N08 N09 1.84e-01
C10 N09 N10 1.27e-06
R10 N09 N10 2.26e-02
L11 N10 N11 1.11e-10
R11 N10 N11 1.65e-01
C12 N11 N12 1.23e-07
L12 N11 N12 1.97e-11
R12 N11 N12 5.49e-02
C13 N12 N13 3.90e-08
L13 N12 N13 2.88e-11
R13 N12 N13 8.92e-02
C14 N13 N14 8.33e-12
L14 N13 N14 7.73e-11
R14 N13 N14 1.56e+01
C15 N14 Port2 2.19e-12
L15 N14 Port2 1.45e-10
R15 N14 Port2 2.99e+01
.ENDS GCD188R71H183MA01

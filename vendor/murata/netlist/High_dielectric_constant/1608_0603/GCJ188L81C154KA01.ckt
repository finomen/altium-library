*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/16[V]
* Murata P/N :GCJ188L81C154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81C154KA01 Port1 Port2
C01 Port1 N01 1.44e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 1.89e-10
R03 N02 N03 8.85e-02
C04 N03 N04 1.45e-05
R04 N03 N04 3.47e-01
C05 N04 N05 1.57e-05
R05 N04 N05 5.74e-02
C06 N05 N06 7.20e-06
R06 N05 N06 1.67e-02
L07 N06 N07 2.48e-11
R07 N06 N07 1.52e-01
L08 N07 N08 1.59e-10
R08 N07 N08 7.01e-02
C09 N08 N09 8.81e-07
L09 N08 N09 2.29e-11
R09 N08 N09 1.16e-02
C10 N09 N10 2.25e-07
L10 N09 N10 3.72e-11
R10 N09 N10 2.29e-02
C11 N10 Port2 2.70e-12
L11 N10 Port2 1.39e-10
R11 N10 Port2 2.62e+01
.ENDS GCJ188L81C154KA01

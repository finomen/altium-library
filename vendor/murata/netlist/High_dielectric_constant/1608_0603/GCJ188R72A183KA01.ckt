*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCJ188R72A183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A183KA01 Port1 Port2
C01 Port1 N01 1.72e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.89e-06
R04 N03 N04 6.91e+02
C05 N04 N05 2.22e-06
R05 N04 N05 6.60e+01
C06 N05 N06 2.36e-06
R06 N05 N06 9.54e+00
C07 N06 N07 2.05e-06
R07 N06 N07 1.63e+00
C08 N07 N08 1.52e-06
R08 N07 N08 3.25e-01
C09 N08 N09 1.03e-06
R09 N08 N09 7.39e-02
L10 N09 N10 1.01e-10
R10 N09 N10 2.03e-01
C11 N10 N11 1.57e-07
L11 N10 N11 1.15e-11
R11 N10 N11 1.94e-02
C12 N11 N12 2.49e-08
L12 N11 N12 2.92e-11
R12 N11 N12 5.44e-02
C13 N12 N13 4.68e-11
L13 N12 N13 1.01e-10
R13 N12 N13 1.98e+00
C14 N13 Port2 2.54e-12
L14 N13 Port2 1.06e-10
R14 N13 Port2 1.57e+01
.ENDS GCJ188R72A183KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-03[uF]/100[V]
* Murata P/N :GCD188R72A272MA01
* Property : C = 2.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R72A272MA01 Port1 Port2
C01 Port1 N01 2.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.76e-10
R03 N02 N03 1.08e-01
C04 N03 N04 3.13e-07
R04 N03 N04 4.85e+03
C05 N04 N05 3.98e-07
R05 N04 N05 2.79e+02
C06 N05 N06 3.94e-07
R06 N05 N06 2.73e+01
C07 N06 N07 3.38e-07
R07 N06 N07 4.03e+00
C08 N07 N08 2.20e-07
R08 N07 N08 7.88e-01
C09 N08 N09 1.25e-07
R09 N08 N09 1.99e-01
C10 N09 N10 4.23e-08
R10 N09 N10 6.74e-02
L11 N10 N11 1.33e-10
R11 N10 N11 1.62e+00
C12 N11 N12 1.74e-08
L12 N11 N12 1.40e-11
R12 N11 N12 8.29e-02
C13 N12 N13 2.82e-09
L13 N12 N13 3.44e-11
R13 N12 N13 1.99e-01
C14 N13 N14 1.46e-10
L14 N13 N14 1.69e-11
R14 N13 N14 6.58e-01
C15 N14 Port2 3.58e-12
L15 N14 Port2 1.11e-10
R15 N14 Port2 1.71e+01
.ENDS GCD188R72A272MA01

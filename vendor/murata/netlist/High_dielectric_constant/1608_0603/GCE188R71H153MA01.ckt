*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCE188R71H153MA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H153MA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 4.78e-02
C04 N03 N04 1.88e-06
R04 N03 N04 1.97e+03
C05 N04 N05 3.51e-06
R05 N04 N05 2.06e+02
C06 N05 N06 2.21e-06
R06 N05 N06 4.94e+01
C07 N06 N07 2.03e-06
R07 N06 N07 6.22e+00
C08 N07 N08 2.08e-06
R08 N07 N08 7.31e-01
C09 N08 N09 1.28e-06
R09 N08 N09 2.38e-01
C10 N09 N10 1.25e-06
R10 N09 N10 4.94e-02
L11 N10 N11 9.14e-11
R11 N10 N11 1.83e-01
C12 N11 N12 1.10e-07
L12 N11 N12 1.66e-11
R12 N11 N12 4.72e-02
C13 N12 N13 2.54e-08
L13 N12 N13 3.30e-11
R13 N12 N13 9.64e-02
C14 N13 N14 4.59e-08
L14 N13 N14 5.67e-12
R14 N13 N14 2.58e-02
C15 N14 N15 8.37e-12
L15 N14 N15 7.06e-11
R15 N14 N15 1.14e+01
C16 N15 Port2 3.50e-12
L16 N15 Port2 8.98e-11
R16 N15 Port2 1.77e+01
.ENDS GCE188R71H153MA01

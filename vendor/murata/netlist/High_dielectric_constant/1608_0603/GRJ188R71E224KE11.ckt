*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-01[uF]/25[V]
* Murata P/N :GRJ188R71E224KE11
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E224KE11 Port1 Port2
C01 Port1 N01 2.09e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 2.14e-10
R03 N02 N03 2.07e-02
C04 N03 N04 1.14e-05
R04 N03 N04 2.32e-01
C05 N04 N05 1.62e-05
R05 N04 N05 1.61e-02
L06 N05 N06 1.99e-11
R06 N05 N06 9.36e-02
L07 N06 N07 1.43e-10
R07 N06 N07 6.18e-02
C08 N07 N08 9.45e-07
L08 N07 N08 2.66e-11
R08 N07 N08 1.36e-02
C09 N08 N09 3.50e-07
L09 N08 N09 3.55e-11
R09 N08 N09 2.05e-02
C10 N09 Port2 3.20e-12
L10 N09 Port2 1.19e-10
R10 N09 Port2 1.58e+01
.ENDS GRJ188R71E224KE11

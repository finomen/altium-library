*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+01[uF]/6.3[V]
* Murata P/N :ZRB18AR60J476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AR60J476ME01 Port1 Port2
C01 Port1 N01 3.25e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 3.13e-10
R03 N02 N03 3.06e-03
C04 N03 N04 1.94e-03
R04 N03 N04 1.19e+00
C05 N04 N05 2.37e-03
R05 N04 N05 1.09e-01
C06 N05 N06 2.51e-03
R06 N05 N06 1.49e-02
C07 N06 N07 2.02e-03
R07 N06 N07 1.47e-03
L08 N07 N08 4.59e-11
R08 N07 N08 3.27e-02
L09 N08 N09 1.08e-10
R09 N08 N09 1.71e-02
L10 N09 N10 3.67e-10
R10 N09 N10 7.02e-03
C11 N10 N11 5.89e-04
L11 N10 N11 1.83e-11
R11 N10 N11 5.59e-04
C12 N11 N12 6.19e-05
L12 N11 N12 9.43e-11
R12 N11 N12 1.70e-03
C13 N12 N13 8.51e-10
L13 N12 N13 3.79e-11
R13 N12 N13 1.14e-01
C14 N13 Port2 3.14e-12
L14 N13 Port2 9.09e-11
R14 N13 Port2 1.13e+01
.ENDS ZRB18AR60J476ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCJ188R92A182KA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A182KA01 Port1 Port2
C01 Port1 N01 1.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.66e-10
R03 N02 N03 9.91e-02
C04 N03 N04 9.13e-08
R04 N03 N04 4.36e+04
C05 N04 N05 1.29e-07
R05 N04 N05 3.88e+03
C06 N05 N06 1.03e-07
R06 N05 N06 5.24e+02
C07 N06 N07 8.70e-08
R07 N06 N07 7.23e+01
C08 N07 N08 6.44e-08
R08 N07 N08 1.06e+01
C09 N08 N09 5.35e-08
R09 N08 N09 1.49e+00
C10 N09 N10 3.42e-08
R10 N09 N10 2.70e-01
L11 N10 N11 7.17e-11
R11 N10 N11 5.53e-01
C12 N11 N12 1.84e-08
L12 N11 N12 6.23e-12
R12 N11 N12 7.77e-02
C13 N12 N13 2.55e-09
L13 N12 N13 1.69e-11
R13 N12 N13 2.00e-01
C14 N13 Port2 1.98e-12
L14 N13 Port2 2.47e-10
R14 N13 Port2 6.08e+01
.ENDS GCJ188R92A182KA01

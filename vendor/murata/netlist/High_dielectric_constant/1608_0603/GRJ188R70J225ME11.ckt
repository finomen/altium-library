*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRJ188R70J225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R70J225ME11 Port1 Port2
C01 Port1 N01 1.60e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.00e-10
R03 N02 N03 1.41e-02
C04 N03 N04 3.17e-05
R04 N03 N04 1.68e+02
C05 N04 N05 5.65e-05
R05 N04 N05 9.52e+00
C06 N05 N06 5.33e-05
R06 N05 N06 1.43e+00
C07 N06 N07 4.56e-05
R07 N06 N07 2.22e-01
C08 N07 N08 4.05e-05
R08 N07 N08 3.50e-02
C09 N08 N09 3.62e-05
R09 N08 N09 1.02e-02
L10 N09 N10 4.14e-11
R10 N09 N10 1.13e-01
L11 N10 N11 2.49e-10
R11 N10 N11 3.62e-02
C12 N11 N12 1.90e-05
L12 N11 N12 1.26e-11
R12 N11 N12 3.92e-03
C13 N12 N13 2.79e-06
L13 N12 N13 4.95e-11
R13 N12 N13 9.65e-03
C14 N13 Port2 6.35e-12
L14 N13 Port2 7.06e-11
R14 N13 Port2 1.08e+01
.ENDS GRJ188R70J225ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-02[uF]/25[V]
* Murata P/N :GCD188R71E393KA01
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71E393KA01 Port1 Port2
C01 Port1 N01 4.08e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.93e-11
R03 N02 N03 2.01e-02
C04 N03 N04 4.58e-06
R04 N03 N04 8.69e+02
C05 N04 N05 7.08e-06
R05 N04 N05 1.02e+02
C06 N05 N06 5.34e-06
R06 N05 N06 1.82e+01
C07 N06 N07 4.71e-06
R07 N06 N07 2.51e+00
C08 N07 N08 3.10e-06
R08 N07 N08 3.98e-01
C09 N08 N09 3.98e-06
R09 N08 N09 3.85e-02
C10 N09 N10 3.92e-06
R10 N09 N10 1.40e-02
L11 N10 N11 1.17e-10
R11 N10 N11 1.09e-01
C12 N11 N12 4.98e-07
L12 N11 N12 1.07e-11
R12 N11 N12 2.26e-02
C13 N12 N13 7.11e-08
L13 N12 N13 3.63e-11
R13 N12 N13 6.18e-02
C14 N13 N14 7.63e-12
L14 N13 N14 1.01e-10
R14 N13 N14 1.89e+01
C15 N14 Port2 1.01e-12
L15 N14 Port2 2.52e-10
R15 N14 Port2 2.93e+01
.ENDS GCD188R71E393KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :LLL185R71E103MA11
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71E103MA11 Port1 Port2
C01 Port1 N01 9.64e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 4.18e-11
R03 N02 N03 2.69e-02
C04 N03 N04 1.32e-06
R04 N03 N04 2.07e+03
C05 N04 N05 2.01e-06
R05 N04 N05 3.60e+02
C06 N05 N06 1.17e-06
R06 N05 N06 8.84e+01
C07 N06 N07 1.45e-06
R07 N06 N07 8.71e+00
C08 N07 N08 1.21e-06
R08 N07 N08 1.59e+00
C09 N08 N09 7.72e-07
R09 N08 N09 3.30e-01
C10 N09 N10 6.74e-07
R10 N09 N10 6.75e-02
C11 N10 N11 5.94e-07
R11 N10 N11 1.84e-02
L12 N11 N12 2.37e-11
R12 N11 N12 2.50e-01
C13 N12 N13 1.69e-08
L13 N12 N13 1.03e-11
R13 N12 N13 5.85e-02
C14 N13 N14 4.47e-09
L14 N13 N14 1.13e-11
R14 N13 N14 7.01e-02
C15 N14 Port2 7.63e-12
L15 N14 Port2 4.07e-11
R15 N14 Port2 5.99e+00
.ENDS LLL185R71E103MA11

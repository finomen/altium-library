*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :ZRB186R60J226ME11
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB186R60J226ME11 Port1 Port2
C01 Port1 N01 1.63e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.52e-10
R03 N02 N03 3.58e-03
C04 N03 N04 9.07e-04
R04 N03 N04 2.38e+00
C05 N04 N05 1.23e-03
R05 N04 N05 2.01e-01
C06 N05 N06 1.29e-03
R06 N05 N06 2.68e-02
C07 N06 N07 9.25e-04
R07 N06 N07 3.06e-03
L08 N07 N08 4.44e-11
R08 N07 N08 1.38e-01
L09 N08 N09 8.62e-11
R09 N08 N09 2.96e-02
L10 N09 N10 2.88e-10
R10 N09 N10 1.21e-02
C11 N10 N11 2.40e-05
L11 N10 N11 7.96e-11
R11 N10 N11 1.70e-03
C12 N11 Port2 1.31e-11
L12 N11 Port2 4.80e-11
R12 N11 Port2 3.69e+00
.ENDS ZRB186R60J226ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/100[V]
* Murata P/N :GCE188R72A152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A152KA01 Port1 Port2
C01 Port1 N01 1.58e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-10
R03 N02 N03 2.10e-01
C04 N03 N04 6.59e-08
R04 N03 N04 1.61e+05
C05 N04 N05 2.47e-07
R05 N04 N05 1.25e+03
C06 N05 N06 2.43e-07
R06 N05 N06 1.28e+02
C07 N06 N07 1.84e-07
R07 N06 N07 1.47e+01
C08 N07 N08 1.39e-07
R08 N07 N08 1.96e+00
C09 N08 N09 6.29e-08
R09 N08 N09 4.53e-01
C10 N09 N10 1.92e-08
R10 N09 N10 1.40e-01
L11 N10 N11 1.58e-11
R11 N10 N11 1.12e-01
C12 N11 N12 2.48e-09
L12 N11 N12 1.26e-11
R12 N11 N12 1.88e-01
C13 N12 N13 1.40e-11
L13 N12 N13 2.24e-10
R13 N12 N13 4.51e+00
C14 N13 Port2 1.77e-12
L14 N13 Port2 1.87e-10
R14 N13 Port2 2.43e+01
.ENDS GCE188R72A152KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GRJ188R71E473KE11
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71E473KE11 Port1 Port2
C01 Port1 N01 4.63e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 6.45e-11
R03 N02 N03 9.94e-02
C04 N03 N04 2.77e-06
R04 N03 N04 2.21e+00
C05 N04 N05 6.64e-06
R05 N04 N05 2.32e-01
C06 N05 N06 4.35e-06
R06 N05 N06 7.46e-02
C07 N06 N07 6.05e-06
R07 N06 N07 1.93e-02
L08 N07 N08 1.03e-10
R08 N07 N08 7.70e-02
C09 N08 N09 3.02e-07
L09 N08 N09 1.72e-11
R09 N08 N09 1.73e-02
C10 N09 N10 8.43e-08
L10 N09 N10 2.69e-11
R10 N09 N10 3.47e-02
C11 N10 N11 4.18e-11
L11 N10 N11 1.04e-10
R11 N10 N11 1.44e+00
C12 N11 Port2 7.30e-13
L12 N11 Port2 2.32e-10
R12 N11 Port2 5.76e+01
.ENDS GRJ188R71E473KE11

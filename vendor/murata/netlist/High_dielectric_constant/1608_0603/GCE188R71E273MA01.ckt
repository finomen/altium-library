*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCE188R71E273MA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71E273MA01 Port1 Port2
C01 Port1 N01 2.66e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.73e-02
C04 N03 N04 2.87e-06
R04 N03 N04 1.32e+03
C05 N04 N05 5.28e-06
R05 N04 N05 1.51e+02
C06 N05 N06 3.36e-06
R06 N05 N06 3.30e+01
C07 N06 N07 3.92e-06
R07 N06 N07 3.62e+00
C08 N07 N08 3.34e-06
R08 N07 N08 9.10e-01
C09 N08 N09 1.81e-06
R09 N08 N09 2.32e-01
C10 N09 N10 1.85e-06
R10 N09 N10 3.10e-02
L11 N10 N11 1.00e-10
R11 N10 N11 1.38e-01
C12 N11 N12 1.28e-07
L12 N11 N12 1.98e-11
R12 N11 N12 2.60e-02
C13 N12 N13 4.23e-08
L13 N12 N13 3.09e-11
R13 N12 N13 6.56e-02
C14 N13 N14 4.26e-12
L14 N13 N14 1.83e-10
R14 N13 N14 2.40e+01
C15 N14 Port2 2.64e-12
L15 N14 Port2 1.43e-10
R15 N14 Port2 3.16e+01
.ENDS GCE188R71E273MA01

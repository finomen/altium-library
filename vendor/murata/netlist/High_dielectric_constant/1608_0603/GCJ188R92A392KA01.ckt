*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ188R92A392KA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A392KA01 Port1 Port2
C01 Port1 N01 4.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 6.97e-02
C04 N03 N04 2.32e-07
R04 N03 N04 2.62e+04
C05 N04 N05 2.59e-07
R05 N04 N05 3.15e+03
C06 N05 N06 2.00e-07
R06 N05 N06 3.70e+02
C07 N06 N07 2.72e-07
R07 N06 N07 3.01e+01
C08 N07 N08 3.08e-07
R08 N07 N08 8.47e+00
C09 N08 N09 1.64e-07
R09 N08 N09 4.33e+00
C10 N09 N10 9.91e-08
R10 N09 N10 7.85e-01
C11 N10 N11 8.15e-08
R11 N10 N11 1.02e-01
L12 N11 N12 2.84e-11
R12 N11 N12 9.04e-01
L13 N12 N13 7.63e-11
R13 N12 N13 3.08e-01
C14 N13 N14 3.86e-08
L14 N13 N14 8.38e-12
R14 N13 N14 7.34e-02
C15 N14 N15 6.09e-09
L15 N14 N15 1.99e-11
R15 N14 N15 1.43e-01
C16 N15 Port2 2.56e-12
L16 N15 Port2 1.71e-10
R16 N15 Port2 3.87e+01
.ENDS GCJ188R92A392KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCE188R72A123MA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A123MA01 Port1 Port2
C01 Port1 N01 1.18e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 5.91e-02
C04 N03 N04 1.38e-06
R04 N03 N04 2.55e+03
C05 N04 N05 3.18e-06
R05 N04 N05 1.80e+02
C06 N05 N06 1.73e-06
R06 N05 N06 5.97e+01
C07 N06 N07 1.64e-06
R07 N06 N07 6.70e+00
C08 N07 N08 1.14e-06
R08 N07 N08 1.11e+00
C09 N08 N09 9.45e-07
R09 N08 N09 1.45e-01
C10 N09 N10 8.12e-07
R10 N09 N10 3.66e-02
L11 N10 N11 1.05e-10
R11 N10 N11 1.72e-01
C12 N11 N12 1.36e-07
L12 N11 N12 9.35e-12
R12 N11 N12 3.14e-02
C13 N12 N13 2.46e-08
L13 N12 N13 2.32e-11
R13 N12 N13 8.10e-02
C14 N13 N14 3.62e-12
L14 N13 N14 1.74e-10
R14 N13 N14 2.09e+01
C15 N14 Port2 5.35e-12
L15 N14 Port2 6.93e-11
R15 N14 Port2 2.32e+01
.ENDS GCE188R72A123MA01

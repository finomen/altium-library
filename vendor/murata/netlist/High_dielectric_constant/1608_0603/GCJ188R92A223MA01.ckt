*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GCJ188R92A223MA01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A223MA01 Port1 Port2
C01 Port1 N01 2.11e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.96e-10
R03 N02 N03 3.56e-02
C04 N03 N04 1.36e-06
R04 N03 N04 2.92e+03
C05 N04 N05 1.85e-06
R05 N04 N05 4.53e+02
C06 N05 N06 1.13e-06
R06 N05 N06 1.06e+02
C07 N06 N07 9.51e-07
R07 N06 N07 1.25e+01
C08 N07 N08 9.24e-07
R08 N07 N08 1.57e+00
C09 N08 N09 6.26e-07
R09 N08 N09 3.72e-01
C10 N09 N10 4.38e-07
R10 N09 N10 5.99e-02
L11 N10 N11 2.54e-11
R11 N10 N11 4.16e-01
L12 N11 N12 8.08e-11
R12 N11 N12 1.60e-01
C13 N12 N13 7.20e-08
L13 N12 N13 2.75e-11
R13 N12 N13 6.39e-02
C14 N13 N14 2.76e-08
L14 N13 N14 2.99e-11
R14 N13 N14 9.67e-02
C15 N14 Port2 9.55e-12
L15 N14 Port2 3.16e-11
R15 N14 Port2 1.36e+01
.ENDS GCJ188R92A223MA01

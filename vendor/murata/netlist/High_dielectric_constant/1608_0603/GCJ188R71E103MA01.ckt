*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/25[V]
* Murata P/N :GCJ188R71E103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E103MA01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.70e-10
R03 N02 N03 3.86e-01
C04 N03 N04 1.30e-06
R04 N03 N04 2.64e+03
C05 N04 N05 3.44e-06
R05 N04 N05 2.10e+02
C06 N05 N06 1.59e-06
R06 N05 N06 8.76e+01
C07 N06 N07 1.59e-06
R07 N06 N07 1.10e+01
C08 N07 N08 2.02e-06
R08 N07 N08 1.52e+00
C09 N08 N09 1.33e-06
R09 N08 N09 1.09e+00
C10 N09 N10 8.87e-07
R10 N09 N10 2.60e-01
C11 N10 N11 7.60e-07
R11 N10 N11 9.39e-02
L12 N11 N12 7.75e-11
R12 N11 N12 1.62e-01
C13 N12 N13 2.11e-08
L13 N12 N13 1.82e-11
R13 N12 N13 6.16e-02
C14 N13 N14 5.62e-11
L14 N13 N14 8.21e-11
R14 N13 N14 1.58e+00
C15 N14 Port2 1.43e-12
L15 N14 Port2 1.70e-10
R15 N14 Port2 2.09e+01
.ENDS GCJ188R71E103MA01

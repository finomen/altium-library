*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/50[V]
* Murata P/N :GCD188R71H682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H682KA01 Port1 Port2
C01 Port1 N01 7.08e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.09e-10
R03 N02 N03 5.30e-02
C04 N03 N04 9.80e-07
R04 N03 N04 2.42e+03
C05 N04 N05 1.27e-06
R05 N04 N05 2.71e+02
C06 N05 N06 9.61e-07
R06 N05 N06 4.50e+01
C07 N06 N07 7.79e-07
R07 N06 N07 4.53e+00
C08 N07 N08 6.89e-07
R08 N07 N08 6.08e-01
C09 N08 N09 6.43e-07
R09 N08 N09 1.43e-01
C10 N09 N10 3.92e-07
R10 N09 N10 4.43e-02
L11 N10 N11 7.94e-11
R11 N10 N11 1.82e-01
C12 N11 N12 6.94e-08
L12 N11 N12 9.92e-12
R12 N11 N12 4.81e-02
C13 N12 N13 1.32e-08
L13 N12 N13 2.18e-11
R13 N12 N13 1.03e-01
C14 N13 N14 6.05e-12
L14 N13 N14 1.41e-10
R14 N13 N14 2.05e+01
C15 N14 Port2 1.52e-12
L15 N14 Port2 1.91e-10
R15 N14 Port2 2.93e+01
.ENDS GCD188R71H682KA01

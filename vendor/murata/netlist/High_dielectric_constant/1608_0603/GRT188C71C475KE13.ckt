*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GRT188C71C475KE13
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C71C475KE13 Port1 Port2
C01 Port1 N01 4.36e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.91e-10
R03 N02 N03 2.85e-03
C04 N03 N04 8.22e-05
R04 N03 N04 8.50e+01
C05 N04 N05 3.47e-04
R05 N04 N05 1.44e+00
C06 N05 N06 3.10e-04
R06 N05 N06 1.81e-01
C07 N06 N07 3.28e-04
R07 N06 N07 1.50e-02
C08 N07 N08 2.48e-04
R08 N07 N08 1.80e-03
L09 N08 N09 2.79e-11
R09 N08 N09 1.25e-01
L10 N09 N10 4.30e-11
R10 N09 N10 2.50e-02
L11 N10 N11 2.61e-10
R11 N10 N11 1.83e-02
C12 N11 N12 1.58e-05
L12 N11 N12 4.96e-11
R12 N11 N12 4.85e-03
C13 N12 N13 7.07e-06
L13 N12 N13 5.60e-11
R13 N12 N13 6.06e-03
C14 N13 Port2 3.94e-12
L14 N13 Port2 3.75e-11
R14 N13 Port2 5.82e+00
.ENDS GRT188C71C475KE13

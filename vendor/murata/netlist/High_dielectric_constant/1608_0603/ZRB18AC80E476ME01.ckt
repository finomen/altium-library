*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/4.70e+01[uF]/2.5[V]
* Murata P/N :ZRB18AC80E476ME01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AC80E476ME01 Port1 Port2
C01 Port1 N01 3.37e-05
R01 Port1 N01 1.06e+06
L02 N01 N02 3.45e-10
R03 N02 N03 2.45e-03
C04 N03 N04 2.74e-03
R04 N03 N04 8.78e-01
C05 N04 N05 3.36e-03
R05 N04 N05 1.82e-01
C06 N05 N06 2.76e-03
R06 N05 N06 4.22e-02
C07 N06 N07 4.26e-03
R07 N06 N07 7.13e-03
C08 N07 N08 2.24e-03
R08 N07 N08 1.55e-03
L09 N08 N09 3.18e-11
R09 N08 N09 1.02e-01
L10 N09 N10 8.56e-11
R10 N09 N10 2.29e-02
L11 N10 N11 2.84e-10
R11 N10 N11 5.23e-03
L12 N11 N12 1.63e-10
R12 N11 N12 4.41e-03
C13 N12 N13 3.56e-04
L13 N12 N13 3.08e-11
R13 N12 N13 1.05e-03
C14 N13 N14 6.27e-05
L14 N13 N14 8.88e-11
R14 N13 N14 1.96e-03
C15 N14 Port2 1.19e-11
L15 N14 Port2 3.75e-11
R15 N14 Port2 3.39e+00
.ENDS ZRB18AC80E476ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCE188R71H102MA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H102MA01 Port1 Port2
C01 Port1 N01 1.02e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.30e-11
R03 N02 N03 3.16e-01
C04 N03 N04 8.91e-08
R04 N03 N04 3.24e+04
C05 N04 N05 3.00e-07
R05 N04 N05 1.82e+03
C06 N05 N06 1.76e-07
R06 N05 N06 6.18e+02
C07 N06 N07 1.55e-07
R07 N06 N07 7.78e+01
C08 N07 N08 1.11e-07
R08 N07 N08 1.22e+01
C09 N08 N09 5.87e-08
R09 N08 N09 2.19e+00
C10 N09 N10 2.69e-08
R10 N09 N10 4.24e-01
C11 N10 N11 1.08e-08
R11 N10 N11 1.48e-01
C12 N11 N12 1.45e-11
L12 N11 N12 2.59e-10
R12 N11 N12 4.89e+00
C13 N12 Port2 1.08e-12
L13 N12 Port2 2.54e-10
R13 N12 Port2 2.91e+01
.ENDS GCE188R71H102MA01

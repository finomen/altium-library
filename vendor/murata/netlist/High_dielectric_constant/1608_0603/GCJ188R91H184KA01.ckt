*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-01[uF]/50[V]
* Murata P/N :GCJ188R91H184KA01
* Property : C = 1.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H184KA01 Port1 Port2
C01 Port1 N01 1.63e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 1.93e-10
R03 N02 N03 1.63e-02
C04 N03 N04 6.77e-06
R04 N03 N04 1.06e+03
C05 N04 N05 7.91e-06
R05 N04 N05 8.45e+01
C06 N05 N06 6.55e-06
R06 N05 N06 1.02e+01
C07 N06 N07 5.60e-06
R07 N06 N07 1.17e+00
C08 N07 N08 4.29e-06
R08 N07 N08 1.56e-01
C09 N08 N09 3.51e-06
R09 N08 N09 2.05e-02
L10 N09 N10 2.01e-11
R10 N09 N10 1.11e-01
L11 N10 N11 1.19e-10
R11 N10 N11 6.60e-02
C12 N11 N12 1.53e-06
L12 N11 N12 1.19e-11
R12 N11 N12 1.07e-02
C13 N12 N13 2.17e-07
L13 N12 N13 3.78e-11
R13 N12 N13 2.86e-02
C14 N13 Port2 2.80e-12
L14 N13 Port2 1.56e-10
R14 N13 Port2 3.45e+01
.ENDS GCJ188R91H184KA01

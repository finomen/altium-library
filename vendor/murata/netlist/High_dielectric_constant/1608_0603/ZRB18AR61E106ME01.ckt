*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :ZRB18AR61E106ME01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AR61E106ME01 Port1 Port2
C01 Port1 N01 6.97e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.89e-10
R03 N02 N03 3.41e-03
C04 N03 N04 3.07e-04
R04 N03 N04 4.80e+00
C05 N04 N05 3.21e-04
R05 N04 N05 5.65e-01
C06 N05 N06 3.03e-04
R06 N05 N06 7.21e-02
C07 N06 N07 2.77e-04
R07 N06 N07 9.80e-03
C08 N07 N08 3.39e-04
R08 N07 N08 2.04e-03
L09 N08 N09 2.05e-11
R09 N08 N09 9.75e-02
L10 N09 N10 4.91e-11
R10 N09 N10 3.98e-02
L11 N10 N11 3.50e-10
R11 N10 N11 1.71e-02
C12 N11 N12 3.89e-05
L12 N11 N12 3.59e-11
R12 N11 N12 3.52e-03
C13 N12 N13 2.57e-05
L13 N12 N13 3.11e-11
R13 N12 N13 3.82e-03
C14 N13 Port2 2.88e-12
L14 N13 Port2 1.01e-10
R14 N13 Port2 2.69e+01
.ENDS ZRB18AR61E106ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J475ME02
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J475ME02 Port1 Port2
C01 Port1 N01 3.62e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.90e-10
R03 N02 N03 7.21e-03
C04 N03 N04 1.51e-04
R04 N03 N04 9.99e+00
C05 N04 N05 1.95e-04
R05 N04 N05 9.86e-01
C06 N05 N06 1.99e-04
R06 N05 N06 1.61e-01
C07 N06 N07 1.61e-04
R07 N06 N07 3.09e-02
C08 N07 N08 1.23e-04
R08 N07 N08 6.22e-03
L09 N08 N09 2.26e-11
R09 N08 N09 1.02e-01
L10 N09 N10 2.41e-10
R10 N09 N10 2.48e-02
L11 N10 N11 3.29e-11
R11 N10 N11 2.44e-02
C12 N11 N12 1.56e-05
L12 N11 N12 4.42e-11
R12 N11 N12 5.17e-03
C13 N12 N13 5.94e-06
L13 N12 N13 5.80e-11
R13 N12 N13 7.33e-03
C14 N13 Port2 5.25e-12
L14 N13 Port2 4.86e-11
R14 N13 Port2 8.00e+00
.ENDS GCJ188C70J475ME02

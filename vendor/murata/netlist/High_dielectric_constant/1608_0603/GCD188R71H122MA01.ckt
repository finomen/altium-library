*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-03[uF]/50[V]
* Murata P/N :GCD188R71H122MA01
* Property : C = 1.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H122MA01 Port1 Port2
C01 Port1 N01 1.15e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 2.55e-01
C04 N03 N04 1.03e-07
R04 N03 N04 1.63e+04
C05 N04 N05 1.72e-07
R05 N04 N05 8.15e+02
C06 N05 N06 2.14e-07
R06 N05 N06 8.93e+01
C07 N06 N07 1.77e-07
R07 N06 N07 2.22e+01
C08 N07 N08 1.09e-07
R08 N07 N08 4.79e+00
C09 N08 N09 7.34e-08
R09 N08 N09 8.89e-01
C10 N09 N10 2.13e-08
R10 N09 N10 2.75e-01
C11 N10 N11 1.77e-11
L11 N10 N11 2.04e-10
R11 N10 N11 4.25e+00
C12 N11 Port2 1.60e-12
L12 N11 Port2 1.82e-10
R12 N11 Port2 2.21e+01
.ENDS GCD188R71H122MA01

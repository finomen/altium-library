*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/50[V]
* Murata P/N :GCE188R71H182MA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H182MA01 Port1 Port2
C01 Port1 N01 1.87e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 2.18e-01
C04 N03 N04 2.33e-07
R04 N03 N04 6.70e+03
C05 N04 N05 2.90e-07
R05 N04 N05 5.08e+02
C06 N05 N06 2.86e-07
R06 N05 N06 5.20e+01
C07 N06 N07 2.52e-07
R07 N06 N07 7.59e+00
C08 N07 N08 1.79e-07
R08 N07 N08 1.68e+00
C09 N08 N09 5.72e-08
R09 N08 N09 5.18e-01
C10 N09 N10 3.36e-08
R10 N09 N10 1.05e-01
C11 N10 N11 1.42e-07
R11 N10 N11 3.31e-03
C12 N11 N12 1.19e-09
L12 N11 N12 3.36e-11
R12 N11 N12 2.48e-01
C13 N12 N13 1.07e-11
L13 N12 N13 2.04e-10
R13 N12 N13 3.43e+00
C14 N13 Port2 3.48e-12
L14 N13 Port2 1.14e-10
R14 N13 Port2 1.45e+01
.ENDS GCE188R71H182MA01

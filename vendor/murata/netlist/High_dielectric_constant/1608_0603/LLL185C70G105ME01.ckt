*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7S(-55to125[deg])/1.00e+00[uF]/4[V]
* Murata P/N :LLL185C70G105ME01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185C70G105ME01 Port1 Port2
C01 Port1 N01 7.46e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 5.63e-11
R03 N02 N03 4.35e-03
C04 N03 N04 2.59e-05
R04 N03 N04 7.90e+01
C05 N04 N05 2.29e-05
R05 N04 N05 1.29e+01
C06 N05 N06 1.82e-05
R06 N05 N06 2.09e+00
C07 N06 N07 1.96e-05
R07 N06 N07 2.68e-01
C08 N07 N08 1.89e-05
R08 N07 N08 5.66e-02
C09 N08 N09 1.29e-05
R09 N08 N09 1.43e-02
C10 N09 N10 2.27e-05
R10 N09 N10 3.11e-03
L11 N10 N11 5.54e-12
R11 N10 N11 3.18e-02
L12 N11 N12 3.37e-11
R12 N11 N12 2.48e-02
C13 N12 N13 1.01e-06
L13 N12 N13 2.02e-11
R13 N12 N13 1.51e-02
C14 N13 N14 4.48e-07
L14 N13 N14 1.60e-11
R14 N13 N14 1.60e-02
C15 N14 Port2 2.86e-11
L15 N14 Port2 9.80e-12
R15 N14 Port2 1.02e+00
.ENDS LLL185C70G105ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188L8EH224KA07
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L8EH224KA07 Port1 Port2
C01 Port1 N01 2.18e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 2.42e-10
R03 N02 N03 1.89e-02
C04 N03 N04 3.08e-05
R04 N03 N04 1.20e+02
C05 N04 N05 5.08e-05
R05 N04 N05 1.17e+01
C06 N05 N06 5.30e-05
R06 N05 N06 1.48e+00
C07 N06 N07 7.05e-05
R07 N06 N07 2.34e-01
C08 N07 N08 4.88e-05
R08 N07 N08 8.30e-02
C09 N08 N09 4.55e-05
R09 N08 N09 2.26e-02
C10 N09 N10 2.55e-05
R10 N09 N10 9.31e-03
L11 N10 N11 2.74e-11
R11 N10 N11 7.67e-02
L12 N11 N12 1.96e-10
R12 N11 N12 5.16e-02
C13 N12 N13 3.25e-06
L13 N12 N13 9.18e-12
R13 N12 N13 7.10e-03
C14 N13 N14 8.01e-07
L14 N13 N14 1.72e-11
R14 N13 N14 1.39e-02
C15 N14 Port2 6.48e-12
L15 N14 Port2 7.97e-11
R15 N14 Port2 9.49e+00
.ENDS GCJ188L8EH224KA07

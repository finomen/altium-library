*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.80e-02[uF]/100[V]
* Murata P/N :GCJ188R92A183KA01
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A183KA01 Port1 Port2
C01 Port1 N01 1.76e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.69e-10
R03 N02 N03 3.60e-02
C04 N03 N04 9.78e-07
R04 N03 N04 4.07e+03
C05 N04 N05 1.19e-06
R05 N04 N05 5.24e+02
C06 N05 N06 8.54e-07
R06 N05 N06 7.93e+01
C07 N06 N07 7.44e-07
R07 N06 N07 9.11e+00
C08 N07 N08 5.34e-07
R08 N07 N08 1.48e+00
C09 N08 N09 4.15e-07
R09 N08 N09 1.91e-01
C10 N09 N10 5.97e-07
R10 N09 N10 1.55e-02
L11 N10 N11 8.53e-11
R11 N10 N11 1.82e-01
C12 N11 N12 7.63e-08
L12 N11 N12 2.04e-11
R12 N11 N12 5.85e-02
C13 N12 N13 3.03e-08
L13 N12 N13 2.14e-11
R13 N12 N13 8.98e-02
C14 N13 Port2 3.26e-12
L14 N13 Port2 9.78e-11
R14 N13 Port2 1.37e+01
.ENDS GCJ188R92A183KA01

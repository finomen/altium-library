*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCJ188L81H102KA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H102KA01 Port1 Port2
C01 Port1 N01 1.05e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 9.46e-11
R03 N02 N03 3.66e-01
C04 N03 N04 8.01e-08
R04 N03 N04 4.42e+04
C05 N04 N05 2.03e-07
R05 N04 N05 1.40e+03
C06 N05 N06 1.67e-07
R06 N05 N06 1.72e+02
C07 N06 N07 1.30e-07
R07 N06 N07 2.22e+01
C08 N07 N08 8.66e-08
R08 N07 N08 3.34e+00
C09 N08 N09 5.06e-08
R09 N08 N09 7.78e-01
C10 N09 N10 1.50e-08
R10 N09 N10 2.46e-01
C11 N10 N11 1.31e-11
L11 N10 N11 2.63e-10
R11 N10 N11 5.07e+00
C12 N11 Port2 1.24e-12
L12 N11 Port2 2.34e-10
R12 N11 Port2 1.57e+01
.ENDS GCJ188L81H102KA01

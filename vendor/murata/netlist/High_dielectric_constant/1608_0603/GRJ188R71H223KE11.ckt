*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/50[V]
* Murata P/N :GRJ188R71H223KE11
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H223KE11 Port1 Port2
C01 Port1 N01 2.21e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 2.02e-10
R03 N02 N03 2.97e-01
C04 N03 N04 2.07e-06
R04 N03 N04 1.92e+03
C05 N04 N05 1.39e-05
R05 N04 N05 6.51e+01
C06 N05 N06 3.75e-06
R06 N05 N06 4.20e+01
C07 N06 N07 4.24e-06
R07 N06 N07 6.07e+00
C08 N07 N08 4.69e-06
R08 N07 N08 8.01e-01
C09 N08 N09 2.18e-06
R09 N08 N09 5.17e-01
C10 N09 N10 1.09e-06
R10 N09 N10 1.24e-01
L11 N10 N11 7.32e-11
R11 N10 N11 2.00e-01
C12 N11 N12 2.03e-08
L12 N11 N12 4.33e-11
R12 N11 N12 5.70e-02
C13 N12 N13 1.19e-10
L13 N12 N13 3.68e-11
R13 N12 N13 8.03e-01
C14 N13 Port2 2.14e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 1.42e+01
.ENDS GRJ188R71H223KE11

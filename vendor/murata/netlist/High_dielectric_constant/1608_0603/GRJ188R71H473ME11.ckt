*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GRJ188R71H473ME11
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R71H473ME11 Port1 Port2
C01 Port1 N01 4.71e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 1.89e-10
R03 N02 N03 2.83e-02
C04 N03 N04 2.79e-06
R04 N03 N04 9.48e-01
C05 N04 N05 4.59e-06
R05 N04 N05 5.50e-02
C06 N05 N06 6.17e-06
R06 N05 N06 1.52e-02
L07 N06 N07 1.71e-11
R07 N06 N07 1.50e-01
L08 N07 N08 1.34e-10
R08 N07 N08 1.16e-01
C09 N08 N09 1.95e-07
L09 N08 N09 2.92e-11
R09 N08 N09 3.78e-02
C10 N09 N10 9.35e-08
L10 N09 N10 2.90e-11
R10 N09 N10 4.94e-02
C11 N10 Port2 3.95e-12
L11 N10 Port2 9.63e-11
R11 N10 Port2 1.36e+01
.ENDS GRJ188R71H473ME11

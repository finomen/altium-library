*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :LLL185R71C473MA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71C473MA01 Port1 Port2
C01 Port1 N01 4.46e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.26e-11
R03 N02 N03 1.09e-02
C04 N03 N04 5.08e-06
R04 N03 N04 7.75e+02
C05 N04 N05 5.87e-06
R05 N04 N05 8.50e+01
C06 N05 N06 5.99e-06
R06 N05 N06 1.05e+01
C07 N06 N07 5.78e-06
R07 N06 N07 1.38e+00
C08 N07 N08 5.05e-06
R08 N07 N08 2.45e-01
C09 N08 N09 4.07e-06
R09 N08 N09 4.77e-02
C10 N09 N10 3.38e-06
R10 N09 N10 1.10e-02
L11 N10 N11 2.96e-11
R11 N10 N11 7.65e-02
C12 N11 N12 8.21e-08
L12 N11 N12 1.35e-11
R12 N11 N12 3.62e-02
C13 N12 N13 3.36e-08
L13 N12 N13 1.01e-11
R13 N12 N13 3.41e-02
C14 N13 Port2 6.01e-12
L14 N13 Port2 5.48e-11
R14 N13 Port2 1.46e+01
.ENDS LLL185R71C473MA01

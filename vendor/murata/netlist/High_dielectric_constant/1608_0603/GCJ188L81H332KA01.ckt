*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCJ188L81H332KA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81H332KA01 Port1 Port2
C01 Port1 N01 3.28e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.91e-01
C04 N03 N04 2.83e-07
R04 N03 N04 2.30e+04
C05 N04 N05 5.79e-07
R05 N04 N05 1.16e+03
C06 N05 N06 4.68e-07
R06 N05 N06 1.45e+02
C07 N06 N07 3.97e-07
R07 N06 N07 1.67e+01
C08 N07 N08 3.13e-07
R08 N07 N08 2.11e+00
C09 N08 N09 1.40e-07
R09 N08 N09 3.95e-01
C10 N09 N10 1.42e-07
R10 N09 N10 6.92e-02
C11 N10 N11 7.01e-09
L11 N10 N11 1.69e-11
R11 N10 N11 5.37e-02
C12 N11 N12 9.33e-09
L12 N11 N12 7.96e-12
R12 N11 N12 8.10e-02
C13 N12 N13 3.61e-11
L13 N12 N13 9.10e-11
R13 N12 N13 1.97e+00
C14 N13 Port2 1.20e-12
L14 N13 Port2 2.25e-10
R14 N13 Port2 2.40e+01
.ENDS GCJ188L81H332KA01

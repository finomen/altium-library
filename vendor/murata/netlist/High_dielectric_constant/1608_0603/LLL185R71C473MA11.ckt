*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/4.70e-02[uF]/16[V]
* Murata P/N :LLL185R71C473MA11
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71C473MA11 Port1 Port2
C01 Port1 N01 4.60e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.24e-11
R03 N02 N03 1.07e-02
C04 N03 N04 5.27e-06
R04 N03 N04 7.01e+02
C05 N04 N05 6.23e-06
R05 N04 N05 8.62e+01
C06 N05 N06 5.51e-06
R06 N05 N06 1.16e+01
C07 N06 N07 6.10e-06
R07 N06 N07 1.31e+00
C08 N07 N08 5.43e-06
R08 N07 N08 2.55e-01
C09 N08 N09 3.79e-06
R09 N08 N09 5.59e-02
C10 N09 N10 2.80e-06
R10 N09 N10 1.26e-02
L11 N10 N11 2.86e-11
R11 N10 N11 8.29e-02
C12 N11 N12 7.27e-08
L12 N11 N12 1.52e-11
R12 N11 N12 4.01e-02
C13 N12 N13 3.40e-08
L13 N12 N13 9.51e-12
R13 N12 N13 3.61e-02
C14 N13 Port2 7.94e-12
L14 N13 Port2 3.27e-11
R14 N13 Port2 6.76e+00
.ENDS LLL185R71C473MA11

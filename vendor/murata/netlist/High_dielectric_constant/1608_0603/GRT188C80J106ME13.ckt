*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X6S(-55to105[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GRT188C80J106ME13
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188C80J106ME13 Port1 Port2
C01 Port1 N01 7.01e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 1.81e-10
R03 N02 N03 3.40e-03
C04 N03 N04 2.59e-04
R04 N03 N04 1.30e+01
C05 N04 N05 3.02e-04
R05 N04 N05 1.49e+00
C06 N05 N06 3.06e-04
R06 N05 N06 2.22e-01
C07 N06 N07 3.10e-04
R07 N06 N07 3.57e-02
C08 N07 N08 4.13e-04
R08 N07 N08 7.01e-03
C09 N08 N09 2.22e-04
R09 N08 N09 4.03e-03
L10 N09 N10 3.11e-11
R10 N09 N10 1.46e-01
L11 N10 N11 4.64e-11
R11 N10 N11 2.91e-02
L12 N11 N12 2.75e-10
R12 N11 N12 1.68e-02
C13 N12 N13 3.27e-05
L13 N12 N13 3.54e-11
R13 N12 N13 4.65e-03
C14 N13 N14 1.07e-05
L14 N13 N14 5.67e-11
R14 N13 N14 4.70e-03
C15 N14 Port2 7.85e-12
L15 N14 Port2 4.56e-11
R15 N14 Port2 8.11e+00
.ENDS GRT188C80J106ME13

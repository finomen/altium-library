*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :LLL185R71H472MA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71H472MA01 Port1 Port2
C01 Port1 N01 4.68e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-11
R03 N02 N03 3.60e-02
C04 N03 N04 4.75e-07
R04 N03 N04 4.30e+03
C05 N04 N05 5.73e-07
R05 N04 N05 2.53e+02
C06 N05 N06 5.76e-07
R06 N05 N06 2.42e+01
C07 N06 N07 4.79e-07
R07 N06 N07 2.90e+00
C08 N07 N08 3.59e-07
R08 N07 N08 4.43e-01
C09 N08 N09 2.50e-07
R09 N08 N09 9.10e-02
C10 N09 N10 9.69e-08
R10 N09 N10 1.83e-02
L11 N10 N11 1.64e-11
R11 N10 N11 1.54e-01
C12 N11 N12 6.76e-09
L12 N11 N12 1.04e-11
R12 N11 N12 8.72e-02
C13 N12 N13 2.28e-09
L13 N12 N13 7.70e-12
R13 N12 N13 9.95e-02
C14 N13 Port2 5.53e-12
L14 N13 Port2 5.91e-11
R14 N13 Port2 8.35e+00
.ENDS LLL185R71H472MA01

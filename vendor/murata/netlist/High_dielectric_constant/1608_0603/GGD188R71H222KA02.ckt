*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/50[V]
* Murata P/N :GGD188R71H222KA02
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGD188R71H222KA02 Port1 Port2
C01 Port1 N01 2.23e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 1.35e-01
C04 N03 N04 2.14e-07
R04 N03 N04 8.37e+03
C05 N04 N05 3.41e-07
R05 N04 N05 4.82e+02
C06 N05 N06 3.05e-07
R06 N05 N06 5.04e+01
C07 N06 N07 2.85e-07
R07 N06 N07 6.60e+00
C08 N07 N08 1.98e-07
R08 N07 N08 1.19e+00
C09 N08 N09 1.12e-07
R09 N08 N09 2.96e-01
C10 N09 N10 3.60e-08
R10 N09 N10 9.70e-02
C11 N10 N11 1.79e-08
L11 N10 N11 9.54e-12
R11 N10 N11 6.42e-02
C12 N11 N12 2.19e-09
L12 N11 N12 2.83e-11
R12 N11 N12 1.97e-01
C13 N12 N13 1.64e-11
L13 N12 N13 1.53e-10
R13 N12 N13 3.27e+00
C14 N13 Port2 2.06e-12
L14 N13 Port2 1.78e-10
R14 N13 Port2 2.18e+01
.ENDS GGD188R71H222KA02

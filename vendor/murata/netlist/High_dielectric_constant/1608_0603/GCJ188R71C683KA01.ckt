*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-02[uF]/16[V]
* Murata P/N :GCJ188R71C683KA01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C683KA01 Port1 Port2
C01 Port1 N01 6.42e-08
R01 Port1 N01 7.35e+09
L02 N01 N02 1.63e-10
R03 N02 N03 7.94e-02
C04 N03 N04 9.62e-06
R04 N03 N04 1.53e+02
C05 N04 N05 1.24e-05
R05 N04 N05 1.53e+01
C06 N05 N06 1.07e-05
R06 N05 N06 2.54e+00
C07 N06 N07 8.48e-06
R07 N06 N07 3.94e-01
C08 N07 N08 6.20e-06
R08 N07 N08 6.48e-02
L09 N08 N09 9.16e-11
R09 N08 N09 1.21e-01
C10 N09 N10 2.39e-07
L10 N09 N10 3.30e-11
R10 N09 N10 2.12e-02
C11 N10 N11 7.67e-08
L11 N10 N11 4.33e-11
R11 N10 N11 3.90e-02
C12 N11 N12 6.04e-11
L12 N11 N12 7.49e-11
R12 N11 N12 1.01e+00
C13 N12 Port2 1.53e-12
L13 N12 Port2 1.60e-10
R13 N12 Port2 2.16e+01
.ENDS GCJ188R71C683KA01

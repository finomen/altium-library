*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-01[uF]/50[V]
* Murata P/N :GCJ188R91H224MA01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91H224MA01 Port1 Port2
C01 Port1 N01 2.02e-07
R01 Port1 N01 2.27e+09
L02 N01 N02 1.99e-10
R03 N02 N03 2.11e-02
C04 N03 N04 8.57e-06
R04 N03 N04 4.31e+02
C05 N04 N05 1.17e-05
R05 N04 N05 4.95e+01
C06 N05 N06 9.97e-06
R06 N05 N06 7.84e+00
C07 N06 N07 1.13e-05
R07 N06 N07 1.56e+00
C08 N07 N08 8.06e-06
R08 N07 N08 4.80e-01
C09 N08 N09 8.63e-06
R09 N08 N09 9.08e-02
C10 N09 N10 2.08e-04
R10 N09 N10 6.09e-02
C11 N10 N11 4.06e-06
R11 N10 N11 3.22e-02
L12 N11 N12 2.69e-11
R12 N11 N12 1.80e-01
L13 N12 N13 1.35e-10
R13 N12 N13 6.91e-02
C14 N13 N14 1.16e-06
L14 N13 N14 2.10e-11
R14 N13 N14 1.47e-02
C15 N14 N15 2.55e-07
L15 N14 N15 4.21e-11
R15 N14 N15 2.69e-02
C16 N15 Port2 3.46e-12
L16 N15 Port2 1.08e-10
R16 N15 Port2 3.44e+01
.ENDS GCJ188R91H224MA01

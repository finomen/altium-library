*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GCJ188R91E474KA01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E474KA01 Port1 Port2
C01 Port1 N01 4.06e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.91e-10
R03 N02 N03 1.35e-02
C04 N03 N04 2.26e-05
R04 N03 N04 1.64e+02
C05 N04 N05 2.31e-05
R05 N04 N05 2.91e+01
C06 N05 N06 1.84e-05
R06 N05 N06 4.83e+00
C07 N06 N07 1.46e-05
R07 N06 N07 6.67e-01
C08 N07 N08 1.11e-05
R08 N07 N08 9.00e-02
C09 N08 N09 7.20e-06
R09 N08 N09 9.54e-03
C10 N09 N10 2.98e-05
R10 N09 N10 6.74e-03
L11 N10 N11 8.26e-12
R11 N10 N11 1.31e-01
L12 N11 N12 4.02e-11
R12 N11 N12 1.02e-01
L13 N12 N13 2.27e-10
R13 N12 N13 5.00e-02
C14 N13 N14 2.45e-06
L14 N13 N14 2.19e-11
R14 N13 N14 1.24e-02
C15 N14 N15 1.35e-06
L15 N14 N15 1.93e-11
R15 N14 N15 1.40e-02
C16 N15 Port2 2.19e-12
L16 N15 Port2 8.11e-11
R16 N15 Port2 2.90e+01
.ENDS GCJ188R91E474KA01

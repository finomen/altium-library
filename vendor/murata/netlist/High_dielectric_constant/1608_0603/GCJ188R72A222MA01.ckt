*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ188R72A222MA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A222MA01 Port1 Port2
C01 Port1 N01 2.26e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.84e-10
R03 N02 N03 3.53e-01
C04 N03 N04 2.27e-07
R04 N03 N04 1.04e+04
C05 N04 N05 5.85e-07
R05 N04 N05 6.29e+02
C06 N05 N06 3.73e-07
R06 N05 N06 1.41e+02
C07 N06 N07 3.41e-07
R07 N06 N07 1.62e+01
C08 N07 N08 2.76e-07
R08 N07 N08 3.27e+00
C09 N08 N09 1.19e-07
R09 N08 N09 9.26e-01
C10 N09 N10 6.18e-08
R10 N09 N10 1.98e-01
C11 N10 N11 1.50e-08
L11 N10 N11 1.04e-11
R11 N10 N11 4.43e-02
C12 N11 N12 2.27e-09
L12 N11 N12 2.81e-11
R12 N11 N12 1.83e-01
C13 N12 N13 1.81e-11
L13 N12 N13 1.43e-10
R13 N12 N13 2.99e+00
C14 N13 Port2 2.16e-12
L14 N13 Port2 1.35e-10
R14 N13 Port2 1.55e+01
.ENDS GCJ188R72A222MA01

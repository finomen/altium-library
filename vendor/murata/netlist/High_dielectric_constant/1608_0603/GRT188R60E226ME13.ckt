*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/2.5[V]
* Murata P/N :GRT188R60E226ME13
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60E226ME13 Port1 Port2
C01 Port1 N01 1.22e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.65e-10
R03 N02 N03 2.89e-03
C04 N03 N04 2.86e-04
R04 N03 N04 1.94e+01
C05 N04 N05 4.66e-04
R05 N04 N05 1.12e+00
C06 N05 N06 7.41e-04
R06 N05 N06 6.45e-02
C07 N06 N07 6.03e-04
R07 N06 N07 5.50e-03
L08 N07 N08 2.38e-11
R08 N07 N08 1.54e-01
L09 N08 N09 6.35e-11
R09 N08 N09 4.11e-02
L10 N09 N10 2.89e-10
R10 N09 N10 1.51e-02
C11 N10 N11 1.96e-05
L11 N10 N11 1.09e-10
R11 N10 N11 3.42e-03
C12 N11 N12 1.99e-05
L12 N11 N12 3.83e-11
R12 N11 N12 1.75e-03
C13 N12 Port2 7.46e-12
L13 N12 Port2 5.23e-11
R13 N12 Port2 7.19e+00
.ENDS GRT188R60E226ME13

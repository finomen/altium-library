*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/50[V]
* Murata P/N :GCD188R71H152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H152KA01 Port1 Port2
C01 Port1 N01 1.50e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.79e-10
R03 N02 N03 1.74e-01
C04 N03 N04 1.30e-07
R04 N03 N04 1.57e+04
C05 N04 N05 2.20e-07
R05 N04 N05 6.40e+02
C06 N05 N06 1.80e-07
R06 N05 N06 6.40e+01
C07 N06 N07 1.50e-07
R07 N06 N07 6.76e+00
C08 N07 N08 1.03e-07
R08 N07 N08 1.02e+00
C09 N08 N09 5.28e-08
R09 N08 N09 2.64e-01
C10 N09 N10 1.46e-08
R10 N09 N10 1.17e-01
C11 N10 N11 1.11e-11
L11 N10 N11 2.55e-10
R11 N10 N11 5.48e+00
C12 N11 Port2 2.45e-12
L12 N11 Port2 1.49e-10
R12 N11 Port2 1.57e+01
.ENDS GCD188R71H152KA01

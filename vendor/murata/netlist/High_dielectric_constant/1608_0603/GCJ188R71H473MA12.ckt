*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/50[V]
* Murata P/N :GCJ188R71H473MA12
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H473MA12 Port1 Port2
C01 Port1 N01 4.64e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 1.13e-01
C04 N03 N04 7.90e-06
R04 N03 N04 5.04e+02
C05 N04 N05 1.14e-05
R05 N04 N05 7.99e+01
C06 N05 N06 8.37e-06
R06 N05 N06 1.71e+01
C07 N06 N07 6.91e-06
R07 N06 N07 2.05e+00
C08 N07 N08 4.10e-06
R08 N07 N08 3.37e-01
C09 N08 N09 4.11e-06
R09 N08 N09 4.69e-02
L10 N09 N10 1.50e-10
R10 N09 N10 1.43e-01
C11 N10 N11 3.95e-07
L11 N10 N11 1.42e-11
R11 N10 N11 2.83e-02
C12 N11 N12 8.56e-08
L12 N11 N12 3.06e-11
R12 N11 N12 4.42e-02
C13 N12 Port2 4.43e-12
L13 N12 Port2 8.24e-11
R13 N12 Port2 7.26e+00
.ENDS GCJ188R71H473MA12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.90e-01[uF]/25[V]
* Murata P/N :GCJ188R91E394KA01
* Property : C = 3.90e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R91E394KA01 Port1 Port2
C01 Port1 N01 3.31e-07
R01 Port1 N01 1.28e+09
L02 N01 N02 1.94e-10
R03 N02 N03 1.21e-02
C04 N03 N04 1.86e-05
R04 N03 N04 2.14e+02
C05 N04 N05 2.05e-05
R05 N04 N05 3.73e+01
C06 N05 N06 1.57e-05
R06 N05 N06 5.77e+00
C07 N06 N07 1.77e-05
R07 N06 N07 6.94e-01
C08 N07 N08 1.67e-05
R08 N07 N08 1.66e-01
C09 N08 N09 8.55e-06
R09 N08 N09 4.89e-02
C10 N09 N10 9.42e-06
R10 N09 N10 7.18e-03
L11 N10 N11 3.08e-11
R11 N10 N11 8.41e-02
L12 N11 N12 1.62e-10
R12 N11 N12 4.52e-02
C13 N12 N13 1.78e-06
L13 N12 N13 2.43e-11
R13 N12 N13 1.16e-02
C14 N13 N14 7.21e-07
L14 N13 N14 2.91e-11
R14 N13 N14 1.78e-02
C15 N14 Port2 3.20e-12
L15 N14 Port2 1.37e-10
R15 N14 Port2 2.81e+01
.ENDS GCJ188R91E394KA01

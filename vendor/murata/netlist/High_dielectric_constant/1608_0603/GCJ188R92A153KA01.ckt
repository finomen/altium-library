*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.50e-02[uF]/100[V]
* Murata P/N :GCJ188R92A153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A153KA01 Port1 Port2
C01 Port1 N01 1.45e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.26e-10
R03 N02 N03 4.37e-02
C04 N03 N04 6.35e-07
R04 N03 N04 1.14e+04
C05 N04 N05 7.42e-07
R05 N04 N05 9.44e+02
C06 N05 N06 6.49e-07
R06 N05 N06 1.06e+02
C07 N06 N07 5.32e-07
R07 N06 N07 1.27e+01
C08 N07 N08 4.09e-07
R08 N07 N08 1.60e+00
C09 N08 N09 2.94e-07
R09 N08 N09 2.07e-01
C10 N09 N10 6.20e-07
R10 N09 N10 1.04e-02
L11 N10 N11 1.75e-11
R11 N10 N11 1.59e-01
L12 N11 N12 6.31e-11
R12 N11 N12 1.50e-01
C13 N12 N13 1.22e-07
L13 N12 N13 9.70e-12
R13 N12 N13 3.58e-02
C14 N13 N14 1.55e-08
L14 N13 N14 3.02e-11
R14 N13 N14 8.52e-02
C15 N14 Port2 2.93e-12
L15 N14 Port2 1.70e-10
R15 N14 Port2 5.13e+01
.ENDS GCJ188R92A153KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-02[uF]/25[V]
* Murata P/N :GCJ188R71E473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E473KA01 Port1 Port2
C01 Port1 N01 4.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 6.61e-02
C04 N03 N04 6.30e-06
R04 N03 N04 1.70e+02
C05 N04 N05 9.98e-06
R05 N04 N05 1.38e+01
C06 N05 N06 7.74e-06
R06 N05 N06 3.39e+00
C07 N06 N07 7.17e-06
R07 N06 N07 5.63e-01
C08 N07 N08 7.56e-06
R08 N07 N08 1.11e-01
C09 N08 N09 2.72e-06
R09 N08 N09 5.46e-02
L10 N09 N10 6.87e-11
R10 N09 N10 9.63e-02
C11 N10 N11 5.51e-08
L11 N10 N11 4.25e-11
R11 N10 N11 3.86e-02
C12 N11 N12 6.52e-11
L12 N11 N12 6.96e-11
R12 N11 N12 1.04e+00
C13 N12 Port2 2.18e-12
L13 N12 Port2 1.41e-10
R13 N12 Port2 2.24e+01
.ENDS GCJ188R71E473KA01

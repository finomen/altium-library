*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-01[uF]/16[V]
* Murata P/N :GCJ188R71C184KA01
* Property : C = 1.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C184KA01 Port1 Port2
C01 Port1 N01 1.68e-07
R01 Port1 N01 2.78e+09
L02 N01 N02 2.21e-10
R03 N02 N03 2.32e-02
C04 N03 N04 2.03e-05
R04 N03 N04 1.08e+02
C05 N04 N05 2.76e-05
R05 N04 N05 8.40e+00
C06 N05 N06 2.57e-05
R06 N05 N06 1.16e+00
C07 N06 N07 2.06e-05
R07 N06 N07 2.01e-01
C08 N07 N08 1.08e-05
R08 N07 N08 3.58e-02
L09 N08 N09 1.15e-11
R09 N08 N09 8.91e-02
L10 N09 N10 1.08e-10
R10 N09 N10 7.57e-02
C11 N10 N11 4.41e-07
L11 N10 N11 4.74e-11
R11 N10 N11 1.48e-02
C12 N11 N12 1.92e-07
L12 N11 N12 4.39e-11
R12 N11 N12 2.18e-02
C13 N12 Port2 3.30e-12
L13 N12 Port2 1.59e-10
R13 N12 Port2 2.44e+01
.ENDS GCJ188R71C184KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/1.00e-02[uF]/16[V]
* Murata P/N :LLL185R71C103MA01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71C103MA01 Port1 Port2
C01 Port1 N01 1.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-11
R03 N02 N03 2.58e-02
C04 N03 N04 1.11e-06
R04 N03 N04 2.87e+03
C05 N04 N05 1.47e-06
R05 N04 N05 3.15e+02
C06 N05 N06 1.27e-06
R06 N05 N06 4.99e+01
C07 N06 N07 1.49e-06
R07 N06 N07 5.36e+00
C08 N07 N08 1.28e-06
R08 N07 N08 1.06e+00
C09 N08 N09 8.44e-07
R09 N08 N09 2.61e-01
C10 N09 N10 7.42e-07
R10 N09 N10 5.52e-02
C11 N10 N11 5.89e-07
R11 N10 N11 1.35e-02
L12 N11 N12 1.61e-11
R12 N11 N12 1.08e-01
C13 N12 N13 1.85e-08
L13 N12 N13 8.99e-12
R13 N12 N13 5.87e-02
C14 N13 N14 6.65e-09
L14 N13 N14 7.09e-12
R14 N13 N14 5.76e-02
C15 N14 Port2 4.52e-12
L15 N14 Port2 7.50e-11
R15 N14 Port2 1.31e+01
.ENDS LLL185R71C103MA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-02[uF]/100[V]
* Murata P/N :GCJ188R92A473KA01
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A473KA01 Port1 Port2
C01 Port1 N01 4.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-10
R03 N02 N03 3.62e-02
C04 N03 N04 2.34e-06
R04 N03 N04 1.70e+03
C05 N04 N05 3.40e-06
R05 N04 N05 1.55e+02
C06 N05 N06 2.39e-06
R06 N05 N06 3.47e+01
C07 N06 N07 1.95e-06
R07 N06 N07 4.47e+00
C08 N07 N08 1.70e-06
R08 N07 N08 6.73e-01
C09 N08 N09 1.56e-06
R09 N08 N09 1.27e-01
C10 N09 N10 1.19e-06
R10 N09 N10 3.73e-02
L11 N10 N11 1.53e-11
R11 N10 N11 1.33e-01
L12 N11 N12 9.26e-11
R12 N11 N12 1.12e-01
C13 N12 N13 2.65e-07
L13 N12 N13 1.60e-11
R13 N12 N13 2.45e-02
C14 N13 N14 6.04e-08
L14 N13 N14 2.83e-11
R14 N13 N14 4.87e-02
C15 N14 N15 3.04e-12
L15 N14 N15 1.60e-10
R15 N14 N15 4.15e+01
C16 N15 Port2 9.38e-12
L16 N15 Port2 2.46e-11
R16 N15 Port2 4.97e+00
.ENDS GCJ188R92A473KA01

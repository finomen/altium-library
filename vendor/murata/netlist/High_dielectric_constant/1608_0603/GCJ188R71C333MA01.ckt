*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-02[uF]/16[V]
* Murata P/N :GCJ188R71C333MA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C333MA01 Port1 Port2
C01 Port1 N01 3.35e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 1.41e-01
C04 N03 N04 4.25e-06
R04 N03 N04 6.00e+02
C05 N04 N05 1.18e-05
R05 N04 N05 4.45e+01
C06 N05 N06 5.66e-06
R06 N05 N06 1.90e+01
C07 N06 N07 3.75e-06
R07 N06 N07 3.01e+00
C08 N07 N08 3.05e-06
R08 N07 N08 5.23e-01
C09 N08 N09 3.48e-06
R09 N08 N09 8.38e-02
C10 N09 N10 2.11e-06
R10 N09 N10 4.27e-02
L11 N10 N11 9.97e-11
R11 N10 N11 1.66e-01
C12 N11 N12 3.64e-08
L12 N11 N12 5.29e-11
R12 N11 N12 4.73e-02
C13 N12 N13 6.98e-11
L13 N12 N13 7.73e-11
R13 N12 N13 1.25e+00
C14 N13 Port2 2.00e-12
L14 N13 Port2 1.56e-10
R14 N13 Port2 1.62e+01
.ENDS GCJ188R71C333MA01

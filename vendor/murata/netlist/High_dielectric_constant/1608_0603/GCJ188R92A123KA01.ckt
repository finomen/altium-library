*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.20e-02[uF]/100[V]
* Murata P/N :GCJ188R92A123KA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A123KA01 Port1 Port2
C01 Port1 N01 1.19e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 3.60e-02
C04 N03 N04 6.09e-07
R04 N03 N04 1.08e+04
C05 N04 N05 6.20e-07
R05 N04 N05 1.08e+03
C06 N05 N06 5.06e-07
R06 N05 N06 1.24e+02
C07 N06 N07 4.76e-07
R07 N06 N07 1.30e+01
C08 N07 N08 3.47e-07
R08 N07 N08 1.80e+00
C09 N08 N09 2.47e-07
R09 N08 N09 2.25e-01
C10 N09 N10 2.89e-07
R10 N09 N10 1.87e-02
L11 N10 N11 9.30e-11
R11 N10 N11 1.85e-01
L12 N11 N12 1.17e-11
R12 N11 N12 1.24e-01
C13 N12 N13 5.93e-08
L13 N12 N13 1.93e-11
R13 N12 N13 8.40e-02
C14 N13 N14 2.00e-08
L14 N13 N14 2.59e-11
R14 N13 N14 1.21e-01
C15 N14 Port2 2.23e-12
L15 N14 Port2 1.61e-10
R15 N14 Port2 4.42e+01
.ENDS GCJ188R92A123KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-03[uF]/100[V]
* Murata P/N :GCJ188R92A332KA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A332KA01 Port1 Port2
C01 Port1 N01 3.40e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.88e-10
R03 N02 N03 6.11e-02
C04 N03 N04 1.65e-07
R04 N03 N04 4.13e+04
C05 N04 N05 1.98e-07
R05 N04 N05 4.13e+03
C06 N05 N06 1.62e-07
R06 N05 N06 4.96e+02
C07 N06 N07 1.85e-07
R07 N06 N07 4.63e+01
C08 N07 N08 2.35e-07
R08 N07 N08 1.11e+01
C09 N08 N09 1.18e-07
R09 N08 N09 4.41e+00
C10 N09 N10 7.82e-08
R10 N09 N10 6.69e-01
C11 N10 N11 8.51e-07
R11 N10 N11 2.04e-01
C12 N11 N12 6.35e-08
R12 N11 N12 1.10e-01
L13 N12 N13 3.04e-11
R13 N12 N13 8.44e-01
L14 N13 N14 8.80e-11
R14 N13 N14 4.18e-01
C15 N14 N15 1.61e-08
L15 N14 N15 1.91e-11
R15 N14 N15 1.80e-01
C16 N15 N16 5.79e-09
L16 N15 N16 2.28e-11
R16 N15 N16 2.25e-01
C17 N16 Port2 4.04e-12
L17 N16 Port2 8.35e-11
R17 N16 Port2 2.66e+01
.ENDS GCJ188R92A332KA01

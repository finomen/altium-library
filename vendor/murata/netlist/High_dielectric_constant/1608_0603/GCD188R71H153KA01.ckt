*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCD188R71H153KA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H153KA01 Port1 Port2
C01 Port1 N01 1.50e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.13e-02
C04 N03 N04 1.85e-06
R04 N03 N04 1.85e+03
C05 N04 N05 2.50e-06
R05 N04 N05 1.85e+02
C06 N05 N06 2.26e-06
R06 N05 N06 3.07e+01
C07 N06 N07 2.10e-06
R07 N06 N07 3.96e+00
C08 N07 N08 2.11e-06
R08 N07 N08 6.72e-01
C09 N08 N09 1.37e-06
R09 N08 N09 2.19e-01
C10 N09 N10 8.68e-07
R10 N09 N10 4.75e-02
L11 N10 N11 9.23e-11
R11 N10 N11 1.64e-01
C12 N11 N12 1.12e-07
L12 N11 N12 1.62e-11
R12 N11 N12 4.50e-02
C13 N12 N13 2.52e-08
L13 N12 N13 3.18e-11
R13 N12 N13 8.98e-02
C14 N13 N14 7.10e-12
L14 N13 N14 1.15e-10
R14 N13 N14 1.95e+01
C15 N14 Port2 2.20e-12
L15 N14 Port2 1.58e-10
R15 N14 Port2 2.57e+01
.ENDS GCD188R71H153KA01

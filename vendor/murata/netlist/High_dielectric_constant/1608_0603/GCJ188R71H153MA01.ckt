*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-02[uF]/50[V]
* Murata P/N :GCJ188R71H153MA01
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H153MA01 Port1 Port2
C01 Port1 N01 1.51e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 6.67e-02
C04 N03 N04 2.09e-06
R04 N03 N04 1.90e+03
C05 N04 N05 3.64e-06
R05 N04 N05 2.14e+02
C06 N05 N06 2.47e-06
R06 N05 N06 4.57e+01
C07 N06 N07 2.28e-06
R07 N06 N07 5.75e+00
C08 N07 N08 1.79e-06
R08 N07 N08 7.76e-01
C09 N08 N09 1.22e-06
R09 N08 N09 1.44e-01
C10 N09 N10 6.30e-07
R10 N09 N10 3.50e-02
L11 N10 N11 8.08e-11
R11 N10 N11 1.32e-01
C12 N11 N12 6.88e-08
L12 N11 N12 2.11e-11
R12 N11 N12 2.81e-02
C13 N12 N13 2.33e-08
L13 N12 N13 2.71e-11
R13 N12 N13 5.00e-02
C14 N13 N14 5.17e-11
L14 N13 N14 7.78e-11
R14 N13 N14 9.66e-01
C15 N14 Port2 1.74e-12
L15 N14 Port2 1.72e-10
R15 N14 Port2 2.89e+01
.ENDS GCJ188R71H153MA01

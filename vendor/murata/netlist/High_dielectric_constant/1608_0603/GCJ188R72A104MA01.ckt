*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GCJ188R72A104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A104MA01 Port1 Port2
C01 Port1 N01 9.91e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 1.39e-10
R03 N02 N03 3.51e-02
C04 N03 N04 1.41e-05
R04 N03 N04 2.44e+02
C05 N04 N05 1.94e-05
R05 N04 N05 3.22e+01
C06 N05 N06 2.24e-05
R06 N05 N06 4.05e+00
C07 N06 N07 2.12e-05
R07 N06 N07 9.72e-01
C08 N07 N08 1.32e-05
R08 N07 N08 2.80e-01
C09 N08 N09 7.40e-06
R09 N08 N09 3.70e-02
L10 N09 N10 1.36e-10
R10 N09 N10 8.09e-02
L11 N10 N11 1.12e-11
R11 N10 N11 6.27e-02
C12 N11 N12 5.56e-07
L12 N11 N12 2.55e-11
R12 N11 N12 1.86e-02
C13 N12 N13 2.05e-07
L13 N12 N13 1.97e-11
R13 N12 N13 1.69e-02
C14 N13 Port2 1.99e-12
L14 N13 Port2 1.61e-10
R14 N13 Port2 1.95e+01
.ENDS GCJ188R72A104MA01

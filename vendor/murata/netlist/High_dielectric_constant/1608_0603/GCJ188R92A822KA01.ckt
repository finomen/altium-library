*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/8.20e-03[uF]/100[V]
* Murata P/N :GCJ188R92A822KA01
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A822KA01 Port1 Port2
C01 Port1 N01 7.85e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 6.33e-02
C04 N03 N04 4.05e-07
R04 N03 N04 2.98e+03
C05 N04 N05 5.61e-07
R05 N04 N05 2.65e+02
C06 N05 N06 4.60e-07
R06 N05 N06 6.98e+01
C07 N06 N07 3.11e-07
R07 N06 N07 1.18e+01
C08 N07 N08 2.20e-07
R08 N07 N08 1.73e+00
C09 N08 N09 1.40e-07
R09 N08 N09 2.08e-01
L10 N09 N10 7.44e-11
R10 N09 N10 2.70e-01
C11 N10 N11 7.04e-08
L11 N10 N11 9.08e-12
R11 N10 N11 5.84e-02
C12 N11 N12 1.28e-08
L12 N11 N12 2.09e-11
R12 N11 N12 1.26e-01
C13 N12 Port2 2.33e-12
L13 N12 Port2 2.05e-10
R13 N12 Port2 6.44e+01
.ENDS GCJ188R92A822KA01

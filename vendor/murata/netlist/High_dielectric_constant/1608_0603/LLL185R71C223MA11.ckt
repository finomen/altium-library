*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/2.20e-02[uF]/16[V]
* Murata P/N :LLL185R71C223MA11
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71C223MA11 Port1 Port2
C01 Port1 N01 2.15e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 4.40e-11
R03 N02 N03 2.17e-02
C04 N03 N04 2.14e-06
R04 N03 N04 1.86e+03
C05 N04 N05 3.24e-06
R05 N04 N05 1.66e+02
C06 N05 N06 2.81e-06
R06 N05 N06 2.57e+01
C07 N06 N07 2.64e-06
R07 N06 N07 3.31e+00
C08 N07 N08 2.93e-06
R08 N07 N08 5.08e-01
C09 N08 N09 1.53e-06
R09 N08 N09 1.41e-01
C10 N09 N10 1.39e-06
R10 N09 N10 2.01e-02
L11 N10 N11 1.78e-11
R11 N10 N11 8.59e-02
C12 N11 N12 4.56e-08
L12 N11 N12 6.23e-12
R12 N11 N12 2.00e-02
C13 N12 N13 1.13e-08
L13 N12 N13 6.51e-12
R13 N12 N13 2.69e-02
C14 N13 Port2 6.00e-12
L14 N13 Port2 6.00e-11
R14 N13 Port2 8.68e+00
.ENDS LLL185R71C223MA11

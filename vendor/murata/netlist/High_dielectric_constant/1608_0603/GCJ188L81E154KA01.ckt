*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8L(-55to150[deg])/1.50e-01[uF]/25[V]
* Murata P/N :GCJ188L81E154KA01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188L81E154KA01 Port1 Port2
C01 Port1 N01 1.45e-07
R01 Port1 N01 3.33e+09
L02 N01 N02 2.30e-10
R03 N02 N03 2.14e-02
C04 N03 N04 1.75e-05
R04 N03 N04 7.69e+01
C05 N04 N05 2.72e-05
R05 N04 N05 7.69e+00
C06 N05 N06 2.50e-05
R06 N05 N06 1.98e+00
C07 N06 N07 2.17e-05
R07 N06 N07 4.23e-01
C08 N07 N08 1.71e-05
R08 N07 N08 9.46e-02
C09 N08 N09 1.15e-05
R09 N08 N09 2.17e-02
L10 N09 N10 1.50e-11
R10 N09 N10 1.08e-01
L11 N10 N11 8.87e-11
R11 N10 N11 9.06e-02
C12 N11 N12 9.30e-07
L12 N11 N12 1.98e-11
R12 N11 N12 1.28e-02
C13 N12 N13 1.30e-07
L13 N12 N13 6.21e-11
R13 N12 N13 3.61e-02
C14 N13 Port2 4.28e-12
L14 N13 Port2 1.07e-10
R14 N13 Port2 1.76e+01
.ENDS GCJ188L81E154KA01

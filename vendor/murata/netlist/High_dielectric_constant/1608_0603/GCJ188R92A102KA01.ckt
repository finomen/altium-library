*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/1.00e-03[uF]/100[V]
* Murata P/N :GCJ188R92A102KA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A102KA01 Port1 Port2
C01 Port1 N01 9.53e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-10
R03 N02 N03 1.35e-01
C04 N03 N04 4.52e-08
R04 N03 N04 4.20e+04
C05 N04 N05 5.40e-08
R05 N04 N05 3.04e+03
C06 N05 N06 4.88e-08
R06 N05 N06 3.66e+02
C07 N06 N07 3.36e-08
R07 N06 N07 5.59e+01
C08 N07 N08 2.81e-08
R08 N07 N08 7.30e+00
C09 N08 N09 2.33e-08
R09 N08 N09 1.17e+00
C10 N09 N10 1.57e-08
R10 N09 N10 2.44e-01
L11 N10 N11 8.47e-11
R11 N10 N11 2.10e+00
C12 N11 N12 6.82e-09
L12 N11 N12 8.90e-12
R12 N11 N12 1.45e-01
C13 N12 N13 1.00e-09
L13 N12 N13 2.35e-11
R13 N12 N13 4.23e-01
C14 N13 N14 4.39e-12
L14 N13 N14 1.28e-10
R14 N13 N14 4.09e+01
C15 N14 Port2 2.63e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 2.56e+01
.ENDS GCJ188R92A102KA01

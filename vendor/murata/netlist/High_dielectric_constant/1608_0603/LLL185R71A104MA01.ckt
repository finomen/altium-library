*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7R(-55to125[deg])/1.00e-01[uF]/10[V]
* Murata P/N :LLL185R71A104MA01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R71A104MA01 Port1 Port2
C01 Port1 N01 9.41e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 4.10e-11
R03 N02 N03 7.00e-03
C04 N03 N04 8.39e-06
R04 N03 N04 4.74e+02
C05 N04 N05 1.20e-05
R05 N04 N05 3.85e+01
C06 N05 N06 8.88e-06
R06 N05 N06 6.55e+00
C07 N06 N07 1.12e-05
R07 N06 N07 4.74e-01
C08 N07 N08 1.38e-05
R08 N07 N08 8.57e-02
C09 N08 N09 8.88e-06
R09 N08 N09 2.62e-02
C10 N09 N10 6.16e-06
R10 N09 N10 5.43e-03
L11 N10 N11 3.65e-11
R11 N10 N11 5.73e-02
L12 N11 N12 1.92e-13
R12 N11 N12 2.41e-03
C13 N12 N13 1.65e-07
L13 N12 N13 1.57e-11
R13 N12 N13 2.58e-02
C14 N13 N14 8.15e-08
L14 N13 N14 1.05e-11
R14 N13 N14 2.31e-02
C15 N14 Port2 6.35e-12
L15 N14 Port2 5.10e-11
R15 N14 Port2 9.53e+00
.ENDS LLL185R71A104MA01

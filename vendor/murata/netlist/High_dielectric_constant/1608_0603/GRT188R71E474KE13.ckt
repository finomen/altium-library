*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/25[V]
* Murata P/N :GRT188R71E474KE13
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R71E474KE13 Port1 Port2
C01 Port1 N01 3.65e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.08e-10
R03 N02 N03 9.32e-03
C04 N03 N04 1.32e-05
R04 N03 N04 8.76e+01
C05 N04 N05 1.49e-05
R05 N04 N05 7.63e+00
C06 N05 N06 1.40e-05
R06 N05 N06 1.03e+00
C07 N06 N07 1.19e-05
R07 N06 N07 1.86e-01
C08 N07 N08 1.04e-05
R08 N07 N08 3.88e-02
C09 N08 N09 8.18e-06
R09 N08 N09 9.64e-03
L10 N09 N10 2.14e-11
R10 N09 N10 1.12e-01
L11 N10 N11 1.34e-10
R11 N10 N11 5.90e-02
C12 N11 N12 2.03e-06
L12 N11 N12 2.31e-11
R12 N11 N12 1.24e-02
C13 N12 N13 4.11e-07
L13 N12 N13 5.52e-11
R13 N12 N13 2.33e-02
C14 N13 Port2 7.10e-12
L14 N13 Port2 6.66e-11
R14 N13 Port2 1.22e+01
.ENDS GRT188R71E474KE13

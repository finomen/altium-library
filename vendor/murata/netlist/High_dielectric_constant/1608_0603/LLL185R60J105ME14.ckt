*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X5R(-55to85[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :LLL185R60J105ME14
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185R60J105ME14 Port1 Port2
C01 Port1 N01 7.99e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.33e-11
R03 N02 N03 3.96e-03
C04 N03 N04 1.41e-05
R04 N03 N04 3.45e+02
C05 N04 N05 2.34e-05
R05 N04 N05 1.80e+01
C06 N05 N06 2.14e-05
R06 N05 N06 2.43e+00
C07 N06 N07 2.00e-05
R07 N06 N07 2.94e-01
C08 N07 N08 1.84e-05
R08 N07 N08 4.37e-02
C09 N08 N09 1.16e-05
R09 N08 N09 8.81e-03
L10 N09 N10 8.75e-12
R10 N09 N10 6.59e-02
L11 N10 N11 5.37e-11
R11 N10 N11 2.55e-02
C12 N11 N12 1.24e-06
L12 N11 N12 2.06e-11
R12 N11 N12 1.37e-02
C13 N12 N13 5.87e-07
L13 N12 N13 1.65e-11
R13 N12 N13 1.45e-02
C14 N13 Port2 1.36e-11
L14 N13 Port2 2.03e-11
R14 N13 Port2 4.97e+00
.ENDS LLL185R60J105ME14

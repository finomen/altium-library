*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7S(-55to125[deg])/3.30e+00[uF]/6.3[V]
* Murata P/N :GCJ188C70J335KE02
* Property : C = 3.30e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188C70J335KE02 Port1 Port2
C01 Port1 N01 2.38e-06
R01 Port1 N01 1.52e+07
L02 N01 N02 1.94e-10
R03 N02 N03 1.06e-02
C04 N03 N04 9.33e-05
R04 N03 N04 4.41e+01
C05 N04 N05 1.36e-04
R05 N04 N05 3.02e+00
C06 N05 N06 1.21e-04
R06 N05 N06 4.92e-01
C07 N06 N07 1.08e-04
R07 N06 N07 7.42e-02
C08 N07 N08 7.86e-05
R08 N07 N08 1.25e-02
C09 N08 N09 8.48e-05
R09 N08 N09 1.99e-03
L10 N09 N10 2.15e-11
R10 N09 N10 1.05e-01
L11 N10 N11 3.60e-11
R11 N10 N11 2.78e-02
L12 N11 N12 2.11e-10
R12 N11 N12 2.33e-02
C13 N12 N13 1.14e-05
L13 N12 N13 4.57e-11
R13 N12 N13 4.52e-03
C14 N13 N14 4.20e-06
L14 N13 N14 5.63e-11
R14 N13 N14 7.58e-03
C15 N14 N15 6.55e-12
L15 N14 N15 9.88e-11
R15 N14 N15 1.82e+01
C16 N15 Port2 5.29e-12
L16 N15 Port2 6.62e-11
R16 N15 Port2 1.45e+01
.ENDS GCJ188C70J335KE02

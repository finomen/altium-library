*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCE188R72A222MA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R72A222MA01 Port1 Port2
C01 Port1 N01 2.19e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.63e-01
C04 N03 N04 1.58e-07
R04 N03 N04 2.44e+04
C05 N04 N05 4.07e-07
R05 N04 N05 5.47e+02
C06 N05 N06 3.48e-07
R06 N05 N06 8.87e+01
C07 N06 N07 2.63e-07
R07 N06 N07 1.17e+01
C08 N07 N08 1.93e-07
R08 N07 N08 1.43e+00
C09 N08 N09 8.11e-08
R09 N08 N09 4.08e-01
C10 N09 N10 3.82e-08
R10 N09 N10 7.92e-02
L11 N10 N11 3.97e-11
R11 N10 N11 3.09e-01
C12 N11 N12 2.65e-08
L12 N11 N12 5.99e-12
R12 N11 N12 5.39e-02
C13 N12 N13 2.08e-09
L13 N12 N13 2.80e-11
R13 N12 N13 2.00e-01
C14 N13 N14 1.97e-11
L14 N13 N14 1.30e-10
R14 N13 N14 2.59e+00
C15 N14 Port2 2.81e-12
L15 N14 Port2 1.11e-10
R15 N14 Port2 2.41e+01
.ENDS GCE188R72A222MA01

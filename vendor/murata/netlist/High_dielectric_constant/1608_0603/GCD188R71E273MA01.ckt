*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.70e-02[uF]/25[V]
* Murata P/N :GCD188R71E273MA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71E273MA01 Port1 Port2
C01 Port1 N01 2.52e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 2.80e-02
C04 N03 N04 2.90e-06
R04 N03 N04 1.27e+03
C05 N04 N05 5.77e-06
R05 N04 N05 1.57e+02
C06 N05 N06 3.39e-06
R06 N05 N06 4.84e+01
C07 N06 N07 3.39e-06
R07 N06 N07 7.00e+00
C08 N07 N08 2.33e-06
R08 N07 N08 1.24e+00
C09 N08 N09 1.54e-06
R09 N08 N09 1.92e-01
C10 N09 N10 1.44e-06
R10 N09 N10 1.92e-02
L11 N10 N11 8.58e-11
R11 N10 N11 1.28e-01
C12 N11 N12 5.30e-07
L12 N11 N12 5.25e-12
R12 N11 N12 1.56e-02
C13 N12 N13 3.04e-08
L13 N12 N13 4.00e-11
R13 N12 N13 6.94e-02
C14 N13 N14 4.93e-12
L14 N13 N14 1.83e-10
R14 N13 N14 1.92e+01
C15 N14 Port2 2.87e-12
L15 N14 Port2 1.13e-10
R15 N14 Port2 2.19e+01
.ENDS GCD188R71E273MA01

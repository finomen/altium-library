*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-01[uF]/16[V]
* Murata P/N :GCJ188R71C474KA12
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C474KA12 Port1 Port2
C01 Port1 N01 4.41e-07
R01 Port1 N01 1.06e+09
L02 N01 N02 1.98e-10
R03 N02 N03 4.36e-02
C04 N03 N04 5.14e-05
R04 N03 N04 7.74e+01
C05 N04 N05 6.98e-05
R05 N04 N05 8.30e+00
C06 N05 N06 5.84e-05
R06 N05 N06 1.44e+00
C07 N06 N07 3.97e-05
R07 N06 N07 1.86e-01
C08 N07 N08 2.35e-05
R08 N07 N08 2.71e-02
L09 N08 N09 2.53e-11
R09 N08 N09 1.19e-01
L10 N09 N10 1.77e-10
R10 N09 N10 5.09e-02
C11 N10 N11 2.75e-06
L11 N10 N11 2.16e-11
R11 N10 N11 7.11e-03
C12 N11 N12 8.89e-07
L12 N11 N12 3.15e-11
R12 N11 N12 1.40e-02
C13 N12 N13 9.30e-12
L13 N12 N13 6.18e-11
R13 N12 N13 1.02e+01
C14 N13 Port2 3.44e-12
L14 N13 Port2 7.64e-11
R14 N13 Port2 1.19e+01
.ENDS GCJ188R71C474KA12

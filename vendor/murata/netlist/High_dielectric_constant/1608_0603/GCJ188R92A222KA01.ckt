*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.20e-03[uF]/100[V]
* Murata P/N :GCJ188R92A222KA01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A222KA01 Port1 Port2
C01 Port1 N01 2.14e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 8.35e-02
C04 N03 N04 8.66e-08
R04 N03 N04 1.12e+04
C05 N04 N05 1.28e-07
R05 N04 N05 5.00e+02
C06 N05 N06 1.06e-07
R06 N05 N06 8.30e+01
C07 N06 N07 9.18e-08
R07 N06 N07 1.33e+01
C08 N07 N08 7.27e-08
R08 N07 N08 2.48e+00
C09 N08 N09 5.45e-08
R09 N08 N09 5.04e-01
C10 N09 N10 3.41e-08
R10 N09 N10 8.61e-02
L11 N10 N11 7.68e-11
R11 N10 N11 9.13e-01
C12 N11 N12 1.26e-08
L12 N11 N12 1.25e-11
R12 N11 N12 1.20e-01
C13 N12 N13 2.45e-09
L13 N12 N13 2.47e-11
R13 N12 N13 2.62e-01
C14 N13 Port2 2.76e-12
L14 N13 Port2 1.79e-10
R14 N13 Port2 5.44e+01
.ENDS GCJ188R92A222KA01

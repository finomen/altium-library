*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/6.80e-03[uF]/100[V]
* Murata P/N :GCJ188R72A682KA01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A682KA01 Port1 Port2
C01 Port1 N01 6.75e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.11e-01
C04 N03 N04 8.16e-07
R04 N03 N04 7.69e+03
C05 N04 N05 1.07e-06
R05 N04 N05 5.97e+02
C06 N05 N06 1.00e-06
R06 N05 N06 6.40e+01
C07 N06 N07 8.49e-07
R07 N06 N07 7.51e+00
C08 N07 N08 6.49e-07
R08 N07 N08 1.02e+00
C09 N08 N09 3.34e-07
R09 N08 N09 2.01e-01
C10 N09 N10 5.49e-07
R10 N09 N10 1.51e-02
C11 N10 N11 2.37e-08
L11 N10 N11 8.73e-12
R11 N10 N11 5.07e-02
C12 N11 N12 4.65e-09
L12 N11 N12 2.71e-11
R12 N11 N12 1.36e-01
C13 N12 N13 3.22e-11
L13 N12 N13 1.64e-10
R13 N12 N13 2.40e+00
C14 N13 Port2 1.90e-12
L14 N13 Port2 1.64e-10
R14 N13 Port2 2.25e+01
.ENDS GCJ188R72A682KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/10[V]
* Murata P/N :ZRB18AR61A226ME01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AR61A226ME01 Port1 Port2
C01 Port1 N01 1.73e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 3.62e-10
R03 N02 N03 2.59e-03
C04 N03 N04 9.93e-04
R04 N03 N04 7.90e+00
C05 N04 N05 1.52e-03
R05 N04 N05 7.77e-01
C06 N05 N06 1.72e-03
R06 N05 N06 1.87e-01
C07 N06 N07 1.37e-03
R07 N06 N07 3.83e-02
C08 N07 N08 1.09e-03
R08 N07 N08 3.55e-03
L09 N08 N09 2.53e-11
R09 N08 N09 1.47e-01
L10 N09 N10 6.60e-11
R10 N09 N10 3.21e-02
L11 N10 N11 2.99e-10
R11 N10 N11 1.37e-02
C12 N11 N12 1.13e-05
L12 N11 N12 2.20e-10
R12 N11 N12 4.05e-03
C13 N12 Port2 5.45e-12
L13 N12 Port2 4.83e-11
R13 N12 Port2 1.30e+01
.ENDS ZRB18AR61A226ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GCJ188R70J225ME01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R70J225ME01 Port1 Port2
C01 Port1 N01 1.45e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.90e-10
R03 N02 N03 1.77e-02
C04 N03 N04 6.56e-05
R04 N03 N04 2.69e+01
C05 N04 N05 5.45e-05
R05 N04 N05 5.00e+00
C06 N05 N06 5.53e-05
R06 N05 N06 7.64e-01
C07 N06 N07 5.71e-05
R07 N06 N07 1.37e-01
C08 N07 N08 3.23e-05
R08 N07 N08 3.73e-02
C09 N08 N09 2.81e-05
R09 N08 N09 6.65e-03
L10 N09 N10 2.03e-11
R10 N09 N10 1.09e-01
L11 N10 N11 3.22e-11
R11 N10 N11 3.74e-02
L12 N11 N12 2.38e-10
R12 N11 N12 3.14e-02
C13 N12 N13 6.48e-06
L13 N12 N13 3.69e-11
R13 N12 N13 6.24e-03
C14 N13 N14 2.50e-06
L14 N13 N14 4.75e-11
R14 N13 N14 9.73e-03
C15 N14 Port2 4.43e-12
L15 N14 Port2 9.66e-11
R15 N14 Port2 1.87e+01
.ENDS GCJ188R70J225ME01

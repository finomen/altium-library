*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCJ188R72A182KA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A182KA01 Port1 Port2
C01 Port1 N01 1.82e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.11e-01
C04 N03 N04 1.93e-07
R04 N03 N04 3.74e+04
C05 N04 N05 2.90e-07
R05 N04 N05 2.31e+03
C06 N05 N06 2.88e-07
R06 N05 N06 2.31e+02
C07 N06 N07 2.31e-07
R07 N06 N07 3.04e+01
C08 N07 N08 1.63e-07
R08 N07 N08 4.04e+00
C09 N08 N09 9.58e-08
R09 N08 N09 7.24e-01
C10 N09 N10 2.82e-08
R10 N09 N10 1.96e-01
C11 N10 N11 3.54e-09
L11 N10 N11 1.14e-11
R11 N10 N11 1.52e-01
C12 N11 N12 2.96e-11
L12 N11 N12 1.22e-10
R12 N11 N12 2.48e+00
C13 N12 Port2 1.54e-12
L13 N12 Port2 2.15e-10
R13 N12 Port2 2.00e+01
.ENDS GCJ188R72A182KA01

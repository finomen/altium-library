*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-01[uF]/100[V]
* Murata P/N :GRJ188R72A104ME11
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R72A104ME11 Port1 Port2
C01 Port1 N01 9.71e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 2.03e-10
R03 N02 N03 2.56e-02
C04 N03 N04 6.56e-06
R04 N03 N04 3.20e-01
C05 N04 N05 9.31e-06
R05 N04 N05 2.22e-02
C06 N05 N06 8.31e-06
R06 N05 N06 1.75e-03
L07 N06 N07 1.39e-11
R07 N06 N07 8.95e-02
L08 N07 N08 1.18e-10
R08 N07 N08 8.03e-02
C09 N08 N09 5.96e-07
L09 N08 N09 2.15e-11
R09 N08 N09 1.98e-02
C10 N09 N10 1.35e-07
L10 N09 N10 2.86e-11
R10 N09 N10 2.10e-02
C11 N10 Port2 4.42e-12
L11 N10 Port2 9.41e-11
R11 N10 Port2 1.34e+01
.ENDS GRJ188R72A104ME11

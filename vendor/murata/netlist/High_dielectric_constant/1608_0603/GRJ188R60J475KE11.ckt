*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRJ188R60J475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R60J475KE11 Port1 Port2
C01 Port1 N01 3.67e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.70e-10
R03 N02 N03 1.02e-02
C04 N03 N04 2.98e-04
R04 N03 N04 1.78e+01
C05 N04 N05 2.38e-04
R05 N04 N05 3.10e+00
C06 N05 N06 2.69e-04
R06 N05 N06 3.18e-01
C07 N06 N07 2.31e-04
R07 N06 N07 3.47e-02
C08 N07 N08 1.54e-04
R08 N07 N08 5.37e-03
L09 N08 N09 2.43e-11
R09 N08 N09 1.14e-01
L10 N09 N10 2.55e-10
R10 N09 N10 2.25e-02
L11 N10 N11 3.81e-11
R11 N10 N11 2.17e-02
C12 N11 N12 1.22e-05
L12 N11 N12 5.18e-11
R12 N11 N12 3.31e-03
C13 N12 N13 5.47e-06
L13 N12 N13 5.02e-11
R13 N12 N13 4.25e-03
C14 N13 Port2 5.31e-12
L14 N13 Port2 6.44e-11
R14 N13 Port2 1.69e+01
.ENDS GRJ188R60J475KE11

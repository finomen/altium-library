*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCD188R72A392KA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R72A392KA01 Port1 Port2
C01 Port1 N01 3.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 9.85e-02
C04 N03 N04 4.55e-07
R04 N03 N04 3.87e+03
C05 N04 N05 6.31e-07
R05 N04 N05 2.80e+02
C06 N05 N06 6.19e-07
R06 N05 N06 2.87e+01
C07 N06 N07 5.34e-07
R07 N06 N07 4.53e+00
C08 N07 N08 3.76e-07
R08 N07 N08 8.50e-01
C09 N08 N09 2.66e-07
R09 N08 N09 1.86e-01
C10 N09 N10 1.19e-07
R10 N09 N10 6.16e-02
L11 N10 N11 2.30e-10
R11 N10 N11 3.17e+00
C12 N11 N12 1.76e-08
L12 N11 N12 1.77e-11
R12 N11 N12 7.06e-02
C13 N12 N13 5.18e-09
L13 N12 N13 2.45e-11
R13 N12 N13 1.57e-01
C14 N13 Port2 4.17e-12
L14 N13 Port2 8.41e-11
R14 N13 Port2 1.40e+01
.ENDS GCD188R72A392KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/10[V]
* Murata P/N :GRJ188R61A106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ188R61A106ME11 Port1 Port2
C01 Port1 N01 7.30e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.00e-10
R03 N02 N03 7.43e-03
C04 N03 N04 3.22e-04
R04 N03 N04 1.61e+01
C05 N04 N05 4.10e-04
R05 N04 N05 1.22e+00
C06 N05 N06 5.95e-04
R06 N05 N06 1.01e-01
C07 N06 N07 6.64e-04
R07 N06 N07 1.65e-02
C08 N07 N08 2.91e-04
R08 N07 N08 4.03e-03
L09 N08 N09 2.04e-11
R09 N08 N09 9.19e-02
L10 N09 N10 5.81e-11
R10 N09 N10 2.83e-02
L11 N10 N11 2.90e-10
R11 N10 N11 1.54e-02
C12 N11 N12 1.90e-05
L12 N11 N12 6.40e-11
R12 N11 N12 2.53e-03
C13 N12 N13 3.71e-05
L13 N12 N13 1.91e-11
R13 N12 N13 1.62e-03
C14 N13 Port2 8.50e-12
L14 N13 Port2 3.79e-11
R14 N13 Port2 4.20e+00
.ENDS GRJ188R61A106ME11

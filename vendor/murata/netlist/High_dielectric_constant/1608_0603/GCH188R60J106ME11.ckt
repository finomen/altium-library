*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :GCH188R60J106ME11
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R60J106ME11 Port1 Port2
C01 Port1 N01 7.01e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.20e-10
R03 N02 N03 3.30e-03
C04 N03 N04 3.78e-04
R04 N03 N04 4.40e+00
C05 N04 N05 4.27e-04
R05 N04 N05 1.04e+00
C06 N05 N06 3.57e-04
R06 N05 N06 2.20e-01
C07 N06 N07 3.07e-04
R07 N06 N07 3.95e-02
C08 N07 N08 1.98e-04
R08 N07 N08 7.92e-03
L09 N08 N09 3.03e-11
R09 N08 N09 1.27e-01
L10 N09 N10 2.72e-11
R10 N09 N10 2.38e-02
L11 N10 N11 1.97e-10
R11 N10 N11 1.21e-02
L12 N11 N12 8.61e-11
R12 N11 N12 6.90e-03
C13 N12 N13 4.82e-05
L13 N12 N13 2.98e-11
R13 N12 N13 3.83e-03
C14 N13 N14 8.04e-06
L14 N13 N14 8.43e-11
R14 N13 N14 5.64e-03
C15 N14 Port2 3.41e-11
L15 N14 Port2 1.05e-11
R15 N14 Port2 7.71e-01
.ENDS GCH188R60J106ME11

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-03[uF]/50[V]
* Murata P/N :GCJ188R71H562KA01
* Property : C = 5.60e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71H562KA01 Port1 Port2
C01 Port1 N01 5.73e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.32e-01
C04 N03 N04 6.71e-07
R04 N03 N04 1.04e+04
C05 N04 N05 9.09e-07
R05 N04 N05 7.36e+02
C06 N05 N06 9.05e-07
R06 N05 N06 7.36e+01
C07 N06 N07 7.59e-07
R07 N06 N07 9.26e+00
C08 N07 N08 6.08e-07
R08 N07 N08 1.17e+00
C09 N08 N09 2.91e-07
R09 N08 N09 2.16e-01
C10 N09 N10 4.93e-06
R10 N09 N10 6.58e-02
C11 N10 N11 5.09e-07
R11 N10 N11 2.50e-02
C12 N11 N12 8.18e-09
L12 N11 N12 2.01e-11
R12 N11 N12 7.68e-02
C13 N12 N13 6.68e-09
L13 N12 N13 1.66e-11
R13 N12 N13 9.91e-02
C14 N13 N14 2.04e-11
L14 N13 N14 2.68e-10
R14 N13 N14 4.11e+00
C15 N14 Port2 3.07e-12
L15 N14 Port2 1.15e-10
R15 N14 Port2 1.01e+01
.ENDS GCJ188R71H562KA01

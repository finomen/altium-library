*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/5.60e-02[uF]/16[V]
* Murata P/N :GCJ188R71C563KA01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71C563KA01 Port1 Port2
C01 Port1 N01 5.81e-08
R01 Port1 N01 8.93e+09
L02 N01 N02 2.01e-10
R03 N02 N03 9.36e-02
C04 N03 N04 7.59e-06
R04 N03 N04 4.89e+02
C05 N04 N05 1.09e-05
R05 N04 N05 4.26e+01
C06 N05 N06 1.03e-05
R06 N05 N06 7.07e+00
C07 N06 N07 8.36e-06
R07 N06 N07 1.17e+00
C08 N07 N08 5.19e-06
R08 N07 N08 2.04e-01
C09 N08 N09 5.45e-06
R09 N08 N09 2.27e-02
L10 N09 N10 7.80e-11
R10 N09 N10 1.56e-01
C11 N10 N11 4.15e-08
L11 N10 N11 5.63e-11
R11 N10 N11 3.45e-02
C12 N11 N12 1.04e-10
L12 N11 N12 5.30e-11
R12 N11 N12 7.90e-01
C13 N12 Port2 2.11e-12
L13 N12 Port2 1.20e-10
R13 N12 Port2 1.33e+01
.ENDS GCJ188R71C563KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GCJ188R92A472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A472KA01 Port1 Port2
C01 Port1 N01 4.70e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.66e-10
R03 N02 N03 7.35e-02
C04 N03 N04 2.87e-07
R04 N03 N04 8.70e+03
C05 N04 N05 3.19e-07
R05 N04 N05 8.90e+02
C06 N05 N06 2.62e-07
R06 N05 N06 1.17e+02
C07 N06 N07 3.12e-07
R07 N06 N07 1.66e+01
C08 N07 N08 1.76e-07
R08 N07 N08 4.91e+00
C09 N08 N09 1.37e-07
R09 N08 N09 6.65e-01
C10 N09 N10 8.38e-08
R10 N09 N10 1.50e-01
L11 N10 N11 7.09e-11
R11 N10 N11 4.63e-01
C12 N11 N12 2.95e-08
L12 N11 N12 1.33e-11
R12 N11 N12 8.74e-02
C13 N12 N13 5.39e-09
L13 N12 N13 2.82e-11
R13 N12 N13 1.71e-01
C14 N13 Port2 3.20e-12
L14 N13 Port2 1.16e-10
R14 N13 Port2 3.26e+01
.ENDS GCJ188R92A472KA01

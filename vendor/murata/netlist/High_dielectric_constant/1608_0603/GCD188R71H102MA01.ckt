*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-03[uF]/50[V]
* Murata P/N :GCD188R71H102MA01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H102MA01 Port1 Port2
C01 Port1 N01 1.03e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 2.60e-01
C04 N03 N04 7.56e-08
R04 N03 N04 2.59e+04
C05 N04 N05 1.55e-07
R05 N04 N05 9.61e+02
C06 N05 N06 1.32e-07
R06 N05 N06 9.61e+01
C07 N06 N07 1.12e-07
R07 N06 N07 1.18e+01
C08 N07 N08 6.45e-08
R08 N07 N08 2.05e+00
C09 N08 N09 3.13e-08
R09 N08 N09 3.71e-01
C10 N09 N10 2.12e-08
R10 N09 N10 1.08e-01
C11 N10 N11 2.00e-11
L11 N10 N11 2.04e-10
R11 N10 N11 4.40e+00
C12 N11 Port2 1.74e-12
L12 N11 Port2 1.89e-10
R12 N11 Port2 1.87e+01
.ENDS GCD188R71H102MA01

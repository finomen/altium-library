*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0816M(0306)/X7S(-55to125[deg])/4.70e+00[uF]/4[V]
* Murata P/N :LLL185C70G475ME17
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL185C70G475ME17 Port1 Port2
C01 Port1 N01 3.65e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 4.83e-11
R03 N02 N03 2.10e-03
C04 N03 N04 1.05e-04
R04 N03 N04 1.27e+01
C05 N04 N05 1.60e-04
R05 N04 N05 1.00e+00
C06 N05 N06 1.97e-04
R06 N05 N06 1.24e-01
C07 N06 N07 2.11e-04
R07 N06 N07 1.83e-02
C08 N07 N08 2.06e-04
R08 N07 N08 2.90e-03
L09 N08 N09 1.58e-11
R09 N08 N09 1.67e-01
L10 N09 N10 1.27e-11
R10 N09 N10 2.62e-02
L11 N10 N11 6.64e-11
R11 N10 N11 1.33e-02
C12 N11 N12 6.35e-06
L12 N11 N12 2.81e-11
R12 N11 N12 5.91e-03
C13 N12 N13 2.84e-06
L13 N12 N13 2.27e-11
R13 N12 N13 5.45e-03
C14 N13 Port2 9.22e-11
L14 N13 Port2 3.15e-12
R14 N13 Port2 6.94e-01
.ENDS LLL185C70G475ME17

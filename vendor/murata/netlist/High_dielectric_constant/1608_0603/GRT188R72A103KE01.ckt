*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e-02[uF]/100[V]
* Murata P/N :GRT188R72A103KE01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R72A103KE01 Port1 Port2
C01 Port1 N01 1.03e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 2.14e-10
R03 N02 N03 5.94e-02
C04 N03 N04 1.55e-06
R04 N03 N04 1.48e+03
C05 N04 N05 1.74e-06
R05 N04 N05 2.12e+02
C06 N05 N06 1.68e-06
R06 N05 N06 4.80e+01
C07 N06 N07 1.55e-06
R07 N06 N07 1.02e+01
C08 N07 N08 1.22e-06
R08 N07 N08 2.11e+00
C09 N08 N09 7.70e-07
R09 N08 N09 4.82e-01
C10 N09 N10 4.40e-07
R10 N09 N10 9.97e-02
L11 N10 N11 7.49e-11
R11 N10 N11 1.72e-01
C12 N11 N12 4.97e-08
L12 N11 N12 1.01e-11
R12 N11 N12 4.33e-02
C13 N12 N13 4.82e-08
L13 N12 N13 6.95e-12
R13 N12 N13 3.85e-02
C14 N13 N14 5.78e-11
L14 N13 N14 8.08e-11
R14 N13 N14 1.52e+00
C15 N14 Port2 2.56e-12
L15 N14 Port2 1.27e-10
R15 N14 Port2 1.77e+01
.ENDS GRT188R72A103KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.20e-02[uF]/50[V]
* Murata P/N :GCD188R71H123KA01
* Property : C = 1.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H123KA01 Port1 Port2
C01 Port1 N01 1.21e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 3.77e-02
C04 N03 N04 1.47e-06
R04 N03 N04 2.43e+03
C05 N04 N05 2.64e-06
R05 N04 N05 2.43e+02
C06 N05 N06 2.06e-06
R06 N05 N06 5.08e+01
C07 N06 N07 1.63e-06
R07 N06 N07 8.43e+00
C08 N07 N08 1.37e-06
R08 N07 N08 1.34e+00
C09 N08 N09 8.44e-07
R09 N08 N09 2.94e-01
C10 N09 N10 6.79e-07
R10 N09 N10 4.40e-02
L11 N10 N11 8.45e-11
R11 N10 N11 1.68e-01
C12 N11 N12 6.17e-08
L12 N11 N12 2.08e-11
R12 N11 N12 4.41e-02
C13 N12 N13 2.45e-08
L13 N12 N13 2.43e-11
R13 N12 N13 1.01e-01
C14 N13 N14 6.95e-12
L14 N13 N14 1.33e-10
R14 N13 N14 1.89e+01
C15 N14 Port2 1.58e-12
L15 N14 Port2 2.09e-10
R15 N14 Port2 2.92e+01
.ENDS GCD188R71H123KA01

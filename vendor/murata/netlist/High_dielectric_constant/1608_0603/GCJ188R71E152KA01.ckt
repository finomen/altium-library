*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.50e-03[uF]/25[V]
* Murata P/N :GCJ188R71E152KA01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E152KA01 Port1 Port2
C01 Port1 N01 1.55e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 6.54e-11
R03 N02 N03 4.20e-01
C04 N03 N04 1.69e-07
R04 N03 N04 9.65e+03
C05 N04 N05 2.48e-07
R05 N04 N05 6.52e+02
C06 N05 N06 2.23e-07
R06 N05 N06 5.55e+01
C07 N06 N07 1.72e-07
R07 N06 N07 7.62e+00
C08 N07 N08 8.37e-08
R08 N07 N08 1.36e+00
C09 N08 N09 3.22e-08
R09 N08 N09 2.85e-01
C10 N09 N10 8.50e-10
L10 N09 N10 1.83e-11
R10 N09 N10 1.33e-01
C11 N10 N11 1.12e-11
L11 N10 N11 2.36e-10
R11 N10 N11 4.57e+00
C12 N11 Port2 1.46e-12
L12 N11 Port2 2.19e-10
R12 N11 Port2 2.89e+01
.ENDS GCJ188R71E152KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/3.30e-02[uF]/100[V]
* Murata P/N :GCJ188R92A333MA01
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A333MA01 Port1 Port2
C01 Port1 N01 3.02e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.24e-10
R03 N02 N03 4.45e-02
C04 N03 N04 1.38e-06
R04 N03 N04 2.88e+03
C05 N04 N05 2.67e-06
R05 N04 N05 1.95e+02
C06 N05 N06 1.56e-06
R06 N05 N06 5.25e+01
C07 N06 N07 1.21e-06
R07 N06 N07 6.61e+00
C08 N07 N08 7.45e-07
R08 N07 N08 8.83e-01
C09 N08 N09 7.32e-07
R09 N08 N09 8.85e-02
L10 N09 N10 6.79e-11
R10 N09 N10 2.07e-01
C11 N10 N11 5.76e-07
L11 N10 N11 4.29e-12
R11 N10 N11 7.83e-03
C12 N11 N12 1.69e-08
L12 N11 N12 4.80e-11
R12 N11 N12 5.93e-02
C13 N12 N13 5.47e-12
L13 N12 N13 1.23e-10
R13 N12 N13 3.64e+01
C14 N13 Port2 3.13e-12
L14 N13 Port2 1.16e-10
R14 N13 Port2 1.74e+01
.ENDS GCJ188R92A333MA01

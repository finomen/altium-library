*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/100[V]
* Murata P/N :GGD188R72A472KA02
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGD188R72A472KA02 Port1 Port2
C01 Port1 N01 4.80e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 8.37e-02
C04 N03 N04 5.12e-07
R04 N03 N04 3.99e+03
C05 N04 N05 8.03e-07
R05 N04 N05 2.00e+02
C06 N05 N06 1.02e-06
R06 N05 N06 2.35e+01
C07 N06 N07 6.12e-07
R07 N06 N07 6.13e+00
C08 N07 N08 4.49e-07
R08 N07 N08 9.40e-01
C09 N08 N09 3.25e-07
R09 N08 N09 1.63e-01
C10 N09 N10 1.29e-07
R10 N09 N10 6.21e-02
L11 N10 N11 9.76e-11
R11 N10 N11 5.67e-01
C12 N11 N12 3.06e-08
L12 N11 N12 1.54e-11
R12 N11 N12 6.23e-02
C13 N12 N13 5.85e-09
L13 N12 N13 3.33e-11
R13 N12 N13 1.33e-01
C14 N13 N14 5.56e-11
L14 N13 N14 4.16e-11
R14 N13 N14 1.11e+00
C15 N14 Port2 4.03e-12
L15 N14 Port2 9.53e-11
R15 N14 Port2 1.11e+01
.ENDS GGD188R72A472KA02

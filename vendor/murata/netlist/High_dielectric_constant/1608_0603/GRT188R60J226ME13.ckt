*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/2.20e+01[uF]/6.3[V]
* Murata P/N :GRT188R60J226ME13
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT188R60J226ME13 Port1 Port2
C01 Port1 N01 1.42e-05
R01 Port1 N01 2.27e+06
L02 N01 N02 1.40e-10
R03 N02 N03 2.64e-03
C04 N03 N04 6.40e-04
R04 N03 N04 7.58e+00
C05 N04 N05 9.85e-04
R05 N04 N05 7.93e-01
C06 N05 N06 1.02e-03
R06 N05 N06 1.20e-01
C07 N06 N07 2.19e-03
R07 N06 N07 1.05e-02
C08 N07 N08 1.86e-03
R08 N07 N08 3.87e-03
C09 N08 N09 1.05e-03
R09 N08 N09 1.14e-03
L10 N09 N10 3.35e-11
R10 N09 N10 1.10e-01
L11 N10 N11 6.24e-11
R11 N10 N11 2.31e-02
L12 N11 N12 3.19e-10
R12 N11 N12 1.18e-02
C13 N12 N13 8.65e-05
L13 N12 N13 4.22e-11
R13 N12 N13 1.40e-03
C14 N13 N14 2.49e-05
L14 N13 N14 7.70e-11
R14 N13 N14 2.66e-03
C15 N14 Port2 3.19e-12
L15 N14 Port2 8.26e-11
R15 N14 Port2 2.93e+01
.ENDS GRT188R60J226ME13

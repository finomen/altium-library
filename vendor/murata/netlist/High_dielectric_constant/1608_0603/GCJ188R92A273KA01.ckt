*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8R(-55to150[deg])/2.70e-02[uF]/100[V]
* Murata P/N :GCJ188R92A273KA01
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R92A273KA01 Port1 Port2
C01 Port1 N01 2.70e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 2.83e-02
C04 N03 N04 1.26e-06
R04 N03 N04 6.34e+03
C05 N04 N05 1.44e-06
R05 N04 N05 5.65e+02
C06 N05 N06 1.26e-06
R06 N05 N06 6.20e+01
C07 N06 N07 1.01e-06
R07 N06 N07 7.80e+00
C08 N07 N08 7.88e-07
R08 N07 N08 9.44e-01
C09 N08 N09 5.41e-07
R09 N08 N09 1.42e-01
C10 N09 N10 7.32e-07
R10 N09 N10 1.47e-02
L11 N10 N11 2.59e-11
R11 N10 N11 2.48e-01
L12 N11 N12 1.08e-10
R12 N11 N12 1.38e-01
C13 N12 N13 9.44e-08
L13 N12 N13 3.06e-11
R13 N12 N13 7.25e-02
C14 N13 N14 3.81e-08
L14 N13 N14 3.33e-11
R14 N13 N14 8.49e-02
C15 N14 Port2 4.46e-12
L15 N14 Port2 7.27e-11
R15 N14 Port2 2.24e+01
.ENDS GCJ188R92A273KA01

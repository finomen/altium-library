*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.90e-03[uF]/100[V]
* Murata P/N :GCJ188R72A392KA01
* Property : C = 3.90e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R72A392KA01 Port1 Port2
C01 Port1 N01 4.06e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.36e-10
R03 N02 N03 4.25e-01
C04 N03 N04 6.88e-07
R04 N03 N04 5.37e+03
C05 N04 N05 7.99e-07
R05 N04 N05 7.25e+02
C06 N05 N06 8.64e-07
R06 N05 N06 1.41e+02
C07 N06 N07 5.65e-07
R07 N06 N07 2.40e+01
C08 N07 N08 4.94e-07
R08 N07 N08 3.00e+00
C09 N08 N09 3.59e-07
R09 N08 N09 5.00e-01
C10 N09 N10 1.31e-07
R10 N09 N10 1.64e-01
L11 N10 N11 6.55e-11
R11 N10 N11 2.65e-01
C12 N11 N12 2.27e-08
L12 N11 N12 6.34e-12
R12 N11 N12 5.03e-02
C13 N12 N13 3.52e-08
L13 N12 N13 3.01e-12
R13 N12 N13 1.88e-02
C14 N13 N14 6.63e-11
L14 N13 N14 3.77e-11
R14 N13 N14 8.95e-01
C15 N14 Port2 1.79e-12
L15 N14 Port2 2.04e-10
R15 N14 Port2 3.08e+01
.ENDS GCJ188R72A392KA01

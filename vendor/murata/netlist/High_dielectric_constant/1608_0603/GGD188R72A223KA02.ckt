*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/2.20e-02[uF]/100[V]
* Murata P/N :GGD188R72A223KA02
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GGD188R72A223KA02 Port1 Port2
C01 Port1 N01 2.06e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 2.09e-02
C04 N03 N04 2.53e-06
R04 N03 N04 1.17e+03
C05 N04 N05 5.82e-06
R05 N04 N05 9.94e+01
C06 N05 N06 3.23e-06
R06 N05 N06 3.78e+01
C07 N06 N07 2.72e-06
R07 N06 N07 4.47e+00
C08 N07 N08 1.94e-06
R08 N07 N08 6.61e-01
C09 N08 N09 1.47e-06
R09 N08 N09 9.72e-02
C10 N09 N10 1.10e-06
R10 N09 N10 1.21e-02
L11 N10 N11 1.41e-10
R11 N10 N11 2.03e-01
C12 N11 N12 1.42e-07
L12 N11 N12 1.85e-11
R12 N11 N12 6.11e-02
C13 N12 N13 3.40e-08
L13 N12 N13 3.95e-11
R13 N12 N13 8.81e-02
C14 N13 N14 7.38e-12
L14 N13 N14 7.48e-11
R14 N13 N14 8.21e+00
C15 N14 Port2 1.20e-11
L15 N14 Port2 2.61e-11
R15 N14 Port2 5.89e+00
.ENDS GGD188R72A223KA02

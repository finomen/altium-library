*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.80e-03[uF]/100[V]
* Murata P/N :GCD188R72A182KA01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R72A182KA01 Port1 Port2
C01 Port1 N01 1.84e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 1.52e-01
C04 N03 N04 1.89e-07
R04 N03 N04 9.29e+03
C05 N04 N05 2.58e-07
R05 N04 N05 6.73e+02
C06 N05 N06 2.34e-07
R06 N05 N06 7.05e+01
C07 N06 N07 2.00e-07
R07 N06 N07 8.02e+00
C08 N07 N08 1.34e-07
R08 N07 N08 1.50e+00
C09 N08 N09 7.39e-08
R09 N08 N09 3.69e-01
C10 N09 N10 2.39e-08
R10 N09 N10 1.17e-01
C11 N10 N11 9.71e-10
L11 N10 N11 4.42e-11
R11 N10 N11 2.53e-01
C12 N11 N12 1.71e-11
L12 N11 N12 1.60e-10
R12 N11 N12 3.93e+00
C13 N12 Port2 2.15e-12
L13 N12 Port2 1.82e-10
R13 N12 Port2 1.78e+01
.ENDS GCD188R72A182KA01

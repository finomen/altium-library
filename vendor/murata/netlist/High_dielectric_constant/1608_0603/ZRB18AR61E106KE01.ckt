*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/1.00e+01[uF]/25[V]
* Murata P/N :ZRB18AR61E106KE01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB18AR61E106KE01 Port1 Port2
C01 Port1 N01 7.10e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 3.92e-10
R03 N02 N03 3.73e-03
C04 N03 N04 3.78e-04
R04 N03 N04 4.20e+00
C05 N04 N05 4.15e-04
R05 N04 N05 1.15e+00
C06 N05 N06 3.37e-04
R06 N05 N06 2.49e-01
C07 N06 N07 3.00e-04
R07 N06 N07 4.38e-02
C08 N07 N08 1.92e-04
R08 N07 N08 9.00e-03
L09 N08 N09 2.98e-11
R09 N08 N09 1.10e-01
L10 N09 N10 2.70e-11
R10 N09 N10 1.79e-02
L11 N10 N11 2.11e-10
R11 N10 N11 1.13e-02
L12 N11 N12 9.96e-11
R12 N11 N12 7.54e-03
C13 N12 N13 4.59e-05
L13 N12 N13 3.28e-11
R13 N12 N13 3.88e-03
C14 N13 N14 9.13e-06
L14 N13 N14 7.91e-11
R14 N13 N14 5.47e-03
C15 N14 Port2 3.48e-11
L15 N14 Port2 1.12e-11
R15 N14 Port2 3.34e-01
.ENDS ZRB18AR61E106KE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/4.70e-03[uF]/50[V]
* Murata P/N :GCE188R71H472KA01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCE188R71H472KA01 Port1 Port2
C01 Port1 N01 4.79e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.89e-10
R03 N02 N03 1.08e-01
C04 N03 N04 5.48e-07
R04 N03 N04 6.61e+03
C05 N04 N05 8.66e-07
R05 N04 N05 3.55e+02
C06 N05 N06 8.53e-07
R06 N05 N06 4.17e+01
C07 N06 N07 6.05e-07
R07 N06 N07 5.89e+00
C08 N07 N08 4.13e-07
R08 N07 N08 8.59e-01
C09 N08 N09 2.61e-07
R09 N08 N09 1.30e-01
C10 N09 N10 2.13e-07
R10 N09 N10 4.96e-02
L11 N10 N11 9.54e-11
R11 N10 N11 4.35e-01
C12 N11 N12 4.03e-08
L12 N11 N12 1.15e-11
R12 N11 N12 5.49e-02
C13 N12 N13 8.47e-09
L13 N12 N13 2.42e-11
R13 N12 N13 1.18e-01
C14 N13 N14 5.06e-11
L14 N13 N14 5.12e-11
R14 N13 N14 1.21e+00
C15 N14 Port2 3.35e-12
L15 N14 Port2 1.04e-10
R15 N14 Port2 2.74e+01
.ENDS GCE188R71H472KA01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X5R(-55to85[deg])/4.70e+00[uF]/16[V]
* Murata P/N :GCH188R61C475KE11
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH188R61C475KE11 Port1 Port2
C01 Port1 N01 3.52e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.66e-10
R03 N02 N03 3.74e-03
C04 N03 N04 1.86e-04
R04 N03 N04 2.85e+01
C05 N04 N05 1.99e-04
R05 N04 N05 5.75e+00
C06 N05 N06 1.66e-04
R06 N05 N06 7.81e-01
C07 N06 N07 1.53e-04
R07 N06 N07 8.60e-02
C08 N07 N08 1.08e-04
R08 N07 N08 1.28e-02
C09 N08 N09 1.71e-04
R09 N08 N09 9.11e-04
L10 N09 N10 2.18e-11
R10 N09 N10 1.08e-01
L11 N10 N11 2.63e-10
R11 N10 N11 2.25e-02
L12 N11 N12 3.08e-11
R12 N11 N12 2.22e-02
C13 N12 N13 1.31e-05
L13 N12 N13 4.79e-11
R13 N12 N13 5.75e-03
C14 N13 N14 7.47e-06
L14 N13 N14 4.17e-11
R14 N13 N14 6.47e-03
C15 N14 Port2 2.73e-12
L15 N14 Port2 9.71e-11
R15 N14 Port2 2.45e+01
.ENDS GCH188R61C475KE11

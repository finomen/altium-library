*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/3.30e-03[uF]/50[V]
* Murata P/N :GCD188R71H332MA01
* Property : C = 3.30e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCD188R71H332MA01 Port1 Port2
C01 Port1 N01 3.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 1.05e-01
C04 N03 N04 4.11e-07
R04 N03 N04 4.64e+03
C05 N04 N05 5.87e-07
R05 N04 N05 2.80e+02
C06 N05 N06 5.31e-07
R06 N05 N06 3.60e+01
C07 N06 N07 4.13e-07
R07 N06 N07 5.47e+00
C08 N07 N08 3.13e-07
R08 N07 N08 8.31e-01
C09 N08 N09 1.93e-07
R09 N08 N09 1.90e-01
C10 N09 N10 6.24e-08
R10 N09 N10 6.92e-02
C11 N10 N11 1.67e-08
L11 N10 N11 1.54e-11
R11 N10 N11 6.57e-02
C12 N11 N12 3.75e-09
L12 N11 N12 2.63e-11
R12 N11 N12 1.73e-01
C13 N12 N13 1.10e-11
L13 N12 N13 2.02e-10
R13 N12 N13 3.65e+00
C14 N13 Port2 2.91e-12
L14 N13 Port2 1.24e-10
R14 N13 Port2 1.82e+01
.ENDS GCD188R71H332MA01

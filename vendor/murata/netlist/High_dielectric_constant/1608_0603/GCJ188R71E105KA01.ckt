*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X7R(-55to125[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GCJ188R71E105KA01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ188R71E105KA01 Port1 Port2
C01 Port1 N01 6.40e-07
R01 Port1 N01 5.00e+08
L02 N01 N02 2.12e-10
R03 N02 N03 1.33e-02
C04 N03 N04 2.01e-05
R04 N03 N04 4.23e+01
C05 N04 N05 2.32e-05
R05 N04 N05 4.04e+00
C06 N05 N06 2.07e-05
R06 N05 N06 5.65e-01
C07 N06 N07 1.48e-05
R07 N06 N07 9.95e-02
C08 N07 N08 1.28e-05
R08 N07 N08 1.59e-02
L09 N08 N09 2.90e-11
R09 N08 N09 1.05e-01
L10 N09 N10 1.60e-10
R10 N09 N10 4.71e-02
C11 N10 N11 4.04e-06
L11 N10 N11 2.27e-11
R11 N10 N11 7.55e-03
C12 N11 N12 8.51e-07
L12 N11 N12 5.17e-11
R12 N11 N12 1.58e-02
C13 N12 Port2 4.50e-12
L13 N12 Port2 1.04e-10
R13 N12 Port2 2.01e+01
.ENDS GCJ188R71E105KA01

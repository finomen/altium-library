*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/3.30e-01[uF]/630[V]
* Murata P/N :GC355DD7LQ334KX18
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC355DD7LQ334KX18 Port1 Port2
C01 Port1 N01 3.19e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 2.46e-10
R03 N02 N03 5.58e-03
C04 N03 N04 1.03e-04
R04 N03 N04 3.92e+01
C05 N04 N05 1.70e-04
R05 N04 N05 3.37e+00
C06 N05 N06 1.64e-04
R06 N05 N06 7.35e-01
C07 N06 N07 1.49e-04
R07 N06 N07 1.64e-01
C08 N07 N08 1.60e-04
R08 N07 N08 3.30e-02
C09 N08 N09 9.36e-05
R09 N08 N09 8.50e-03
L10 N09 N10 5.27e-11
R10 N09 N10 4.11e-02
L11 N10 N11 4.34e-11
R11 N10 N11 2.42e-02
L12 N11 N12 3.93e-11
R12 N11 N12 1.71e-02
C13 N12 N13 7.47e-07
L13 N12 N13 6.29e-11
R13 N12 N13 5.82e-02
C14 N13 N14 2.15e-07
L14 N13 N14 7.36e-11
R14 N13 N14 4.71e-02
C15 N14 Port2 1.15e-11
L15 N14 Port2 3.29e-10
R15 N14 Port2 4.34e+01
.ENDS GC355DD7LQ334KX18

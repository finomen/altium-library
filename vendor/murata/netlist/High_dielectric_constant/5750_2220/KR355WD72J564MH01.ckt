*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/5.60e-01[uF]/630[V]
* Murata P/N :KR355WD72J564MH01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355WD72J564MH01 Port1 Port2
C01 Port1 N01 5.26e-07
R01 Port1 N01 1.79e+08
L02 N01 N02 1.07e-11
R03 N02 N03 7.82e-03
C04 N03 N04 1.96e-04
R04 N03 N04 8.10e-03
L05 N04 N05 6.06e-11
R05 N04 N05 4.70e-01
L06 N05 N06 2.67e-10
R06 N05 N06 8.41e-02
L07 N06 N07 4.62e-10
R07 N06 N07 8.64e-03
C08 N07 N08 8.99e-07
L08 N07 N08 2.76e-10
R08 N07 N08 1.30e-01
C09 N08 N09 8.24e-07
L09 N08 N09 8.03e-11
R09 N08 N09 6.08e-02
C10 N09 N10 1.38e-06
L10 N09 N10 3.14e-11
R10 N09 N10 2.41e-02
C11 N10 N11 4.34e-07
L11 N10 N11 4.65e-11
R11 N10 N11 2.78e-02
C12 N11 N12 3.43e-12
L12 N11 N12 1.08e-09
R12 N11 N12 4.03e+02
C13 N12 Port2 2.48e-11
L13 N12 Port2 9.26e-11
R13 N12 Port2 1.31e+01
.ENDS KR355WD72J564MH01

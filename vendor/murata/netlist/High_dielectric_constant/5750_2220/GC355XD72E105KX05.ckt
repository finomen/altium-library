*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :GC355XD72E105KX05
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC355XD72E105KX05 Port1 Port2
C01 Port1 N01 1.05e-06
R01 Port1 N01 1.00e+08
L02 N01 N02 1.44e-10
R03 N02 N03 2.63e-03
C04 N03 N04 4.15e-04
R04 N03 N04 6.21e+00
C05 N04 N05 5.43e-04
R05 N04 N05 9.63e-01
C06 N05 N06 5.11e-04
R06 N05 N06 2.00e-01
C07 N06 N07 4.72e-04
R07 N06 N07 4.16e-02
C08 N07 N08 2.54e-04
R08 N07 N08 1.43e-02
L09 N08 N09 1.68e-10
R09 N08 N09 2.31e-02
L10 N09 N10 1.06e-10
R10 N09 N10 1.64e-02
L11 N10 N11 6.72e-11
R11 N10 N11 8.92e-03
C12 N11 N12 2.16e-06
L12 N11 N12 1.23e-10
R12 N11 N12 6.69e-02
C13 N12 N13 1.04e-06
L13 N12 N13 1.01e-10
R13 N12 N13 4.81e-02
C14 N13 Port2 8.59e-12
L14 N13 Port2 3.21e-10
R14 N13 Port2 4.21e+01
.ENDS GC355XD72E105KX05

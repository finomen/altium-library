*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e+01[uF]/35[V]
* Murata P/N :KCM55WR7YA476MH01
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55WR7YA476MH01 Port1 Port2
C01 Port1 N01 4.33e-05
R01 Port1 N01 2.13e+06
L02 N01 N02 7.95e-12
R03 N02 N03 3.11e-03
C04 N03 N04 7.72e-03
R04 N03 N04 1.57e-01
C05 N04 N05 5.75e-03
R05 N04 N05 3.97e-02
C06 N05 N06 4.37e-03
R06 N05 N06 9.97e-03
L07 N06 N07 1.95e-11
R07 N06 N07 2.64e-01
L08 N07 N08 1.16e-10
R08 N07 N08 4.08e-02
L09 N08 N09 7.94e-10
R09 N08 N09 1.41e-02
L10 N09 N10 1.33e-09
R10 N09 N10 3.94e-03
C11 N10 N11 1.16e-04
L11 N10 N11 2.37e-10
R11 N10 N11 7.65e-03
C12 N11 N12 8.83e-05
L12 N11 N12 8.20e-11
R12 N11 N12 3.49e-03
C13 N12 Port2 2.89e-12
L13 N12 Port2 1.13e-09
R13 N12 Port2 6.01e+02
.ENDS KCM55WR7YA476MH01

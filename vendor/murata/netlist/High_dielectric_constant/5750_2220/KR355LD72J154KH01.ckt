*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :KR355LD72J154KH01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD72J154KH01 Port1 Port2
C01 Port1 N01 1.47e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 1.63e-11
R03 N02 N03 1.62e-02
C04 N03 N04 3.82e-05
R04 N03 N04 3.95e-02
L05 N04 N05 1.38e-10
R05 N04 N05 1.37e-01
L06 N05 N06 2.18e-10
R06 N05 N06 1.43e-02
C07 N06 N07 5.70e-07
L07 N06 N07 4.03e-11
R07 N06 N07 4.51e-02
C08 N07 N08 7.85e-08
L08 N07 N08 8.36e-11
R08 N07 N08 4.81e-02
C09 N08 N09 3.95e-12
L09 N08 N09 1.14e-09
R09 N08 N09 2.63e+02
C10 N09 Port2 1.50e-11
L10 N09 Port2 2.01e-10
R10 N09 Port2 2.82e+01
.ENDS KR355LD72J154KH01

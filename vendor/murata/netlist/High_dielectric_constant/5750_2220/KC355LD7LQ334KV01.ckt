*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/3.30e-01[uF]/630[V]
* Murata P/N :KC355LD7LQ334KV01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355LD7LQ334KV01 Port1 Port2
C01 Port1 N01 3.22e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 7.60e-12
R03 N02 N03 1.07e-02
C04 N03 N04 8.68e-05
R04 N03 N04 2.93e-02
L05 N04 N05 5.36e-11
R05 N04 N05 3.54e-01
L06 N05 N06 2.13e-10
R06 N05 N06 7.93e-02
L07 N06 N07 2.61e-10
R07 N06 N07 6.78e-03
C08 N07 N08 8.95e-07
L08 N07 N08 6.31e-11
R08 N07 N08 4.26e-02
C09 N08 N09 3.15e-07
L09 N08 N09 5.78e-11
R09 N08 N09 4.72e-02
C10 N09 N10 4.82e-12
L10 N09 N10 8.95e-10
R10 N09 N10 1.69e+02
C11 N10 Port2 8.85e-12
L11 N10 Port2 3.52e-10
R11 N10 Port2 5.83e+01
.ENDS KC355LD7LQ334KV01

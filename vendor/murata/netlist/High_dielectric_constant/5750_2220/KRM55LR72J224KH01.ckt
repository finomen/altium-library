*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :KRM55LR72J224KH01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72J224KH01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 9.08e-12
R03 N02 N03 1.83e-02
C04 N03 N04 1.71e-05
R04 N03 N04 6.43e-02
L05 N04 N05 2.18e-10
R05 N04 N05 1.04e-01
L06 N05 N06 8.32e-12
R06 N05 N06 6.67e-02
L07 N06 N07 6.50e-11
R07 N06 N07 6.61e-03
C08 N07 N08 6.25e-07
L08 N07 N08 6.56e-11
R08 N07 N08 4.69e-02
C09 N08 N09 1.78e-07
L09 N08 N09 7.29e-11
R09 N08 N09 5.78e-02
C10 N09 Port2 2.89e-12
L10 N09 Port2 1.25e-09
R10 N09 Port2 5.00e+02
.ENDS KRM55LR72J224KH01

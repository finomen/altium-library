*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e+01[uF]/25[V]
* Murata P/N :KRM55QR71E336KH01
* Property : C = 3.30e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QR71E336KH01 Port1 Port2
C01 Port1 N01 3.18e-05
R01 Port1 N01 3.03e+06
L02 N01 N02 1.10e-11
R03 N02 N03 3.07e-03
C04 N03 N04 4.60e-03
R04 N03 N04 2.49e-01
C05 N04 N05 3.47e-03
R05 N04 N05 4.16e-02
C06 N05 N06 4.08e-03
R06 N05 N06 4.83e-03
L07 N06 N07 9.29e-11
R07 N06 N07 6.50e-02
L08 N07 N08 6.93e-12
R08 N07 N08 4.71e-02
L09 N08 N09 6.62e-10
R09 N08 N09 2.14e-02
L10 N09 N10 1.16e-09
R10 N09 N10 3.33e-03
C11 N10 N11 7.59e-05
L11 N10 N11 1.32e-10
R11 N10 N11 3.24e-03
C12 N11 N12 2.07e-05
L12 N11 N12 1.77e-10
R12 N11 N12 5.55e-03
C13 N12 Port2 2.68e-12
L13 N12 Port2 1.25e-09
R13 N12 Port2 4.99e+02
.ENDS KRM55QR71E336KH01

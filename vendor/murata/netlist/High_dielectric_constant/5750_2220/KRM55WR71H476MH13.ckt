*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e+01[uF]/50[V]
* Murata P/N :KRM55WR71H476MH13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55WR71H476MH13 Port1 Port2
C01 Port1 N01 4.25e-05
R01 Port1 N01 2.13e+06
L02 N01 N02 2.84e-11
R03 N02 N03 2.66e-03
L04 N03 N04 3.11e-12
R04 N03 N04 9.77e-02
L05 N04 N05 6.78e-11
R05 N04 N05 2.82e-02
L06 N05 N06 2.87e-10
R06 N05 N06 1.35e-02
L07 N06 N07 6.10e-10
R07 N06 N07 9.55e-03
L08 N07 N08 1.34e-09
R08 N07 N08 3.16e-03
C09 N08 N09 9.85e-05
L09 N08 N09 2.89e-10
R09 N08 N09 7.23e-03
C10 N09 N10 6.99e-05
L10 N09 N10 1.10e-10
R10 N09 N10 4.02e-03
C11 N10 N11 3.77e-05
L11 N10 N11 7.15e-11
R11 N10 N11 1.92e-03
C12 N11 Port2 3.20e-12
L12 N11 Port2 1.17e-09
R12 N11 Port2 2.74e+02
.ENDS KRM55WR71H476MH13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+01[uF]/100[V]
* Murata P/N :KRM55QR72A106KH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QR72A106KH01 Port1 Port2
C01 Port1 N01 9.79e-06
R01 Port1 N01 1.00e+07
L02 N01 N02 3.48e-11
R03 N02 N03 5.41e-03
C04 N03 N04 1.12e-03
R04 N03 N04 1.02e+00
C05 N04 N05 1.28e-03
R05 N04 N05 8.96e-02
C06 N05 N06 1.12e-03
R06 N05 N06 1.26e-02
L07 N06 N07 1.03e-11
R07 N06 N07 8.75e-02
L08 N07 N08 8.40e-11
R08 N07 N08 7.18e-02
L09 N08 N09 5.57e-10
R09 N08 N09 2.63e-02
L10 N09 N10 4.54e-10
R10 N09 N10 3.18e-03
C11 N10 N11 2.03e-05
L11 N10 N11 1.35e-10
R11 N10 N11 8.33e-03
C12 N11 N12 7.89e-06
L12 N11 N12 1.24e-10
R12 N11 N12 9.47e-03
C13 N12 Port2 2.92e-12
L13 N12 Port2 1.18e-09
R13 N12 Port2 8.80e+02
.ENDS KRM55QR72A106KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e+01[uF]/35[V]
* Murata P/N :KCM55QR7YA226KH01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55QR7YA226KH01 Port1 Port2
C01 Port1 N01 2.13e-05
R01 Port1 N01 4.55e+06
L02 N01 N02 1.83e-11
R03 N02 N03 5.03e-03
C04 N03 N04 2.36e-03
R04 N03 N04 5.14e-01
C05 N04 N05 2.12e-03
R05 N04 N05 4.96e-02
C06 N05 N06 2.60e-03
R06 N05 N06 4.27e-03
L07 N06 N07 1.69e-11
R07 N06 N07 1.71e-01
L08 N07 N08 8.74e-11
R08 N07 N08 5.21e-02
L09 N08 N09 6.40e-10
R09 N08 N09 2.38e-02
L10 N09 N10 6.43e-10
R10 N09 N10 3.69e-03
C11 N10 N11 4.34e-05
L11 N10 N11 1.52e-10
R11 N10 N11 5.36e-03
C12 N11 N12 1.61e-05
L12 N11 N12 1.50e-10
R12 N11 N12 6.99e-03
C13 N12 Port2 3.13e-12
L13 N12 Port2 1.13e-09
R13 N12 Port2 4.68e+02
.ENDS KCM55QR7YA226KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :KRM55LR7LV474KH01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR7LV474KH01 Port1 Port2
C01 Port1 N01 4.60e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 1.52e-11
R03 N02 N03 6.40e-03
C04 N03 N04 3.86e-05
R04 N03 N04 3.13e-02
C05 N04 N05 2.61e-06
R05 N04 N05 9.59e-03
L06 N05 N06 2.31e-10
R06 N05 N06 8.34e-02
L07 N06 N07 3.08e-12
R07 N06 N07 7.19e-02
L08 N07 N08 4.92e-10
R08 N07 N08 1.91e-02
C09 N08 N09 1.35e-06
L09 N08 N09 5.12e-11
R09 N08 N09 1.82e-02
C10 N09 N10 4.44e-07
L10 N09 N10 5.14e-11
R10 N09 N10 2.05e-02
C11 N10 N11 3.58e-12
L11 N10 N11 1.11e-09
R11 N10 N11 2.43e+02
C12 N11 Port2 1.58e-11
L12 N11 Port2 1.99e-10
R12 N11 Port2 2.00e+01
.ENDS KRM55LR7LV474KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/6.80e-01[uF]/250[V]
* Murata P/N :KR355LD72E684KH01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD72E684KH01 Port1 Port2
C01 Port1 N01 6.53e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 9.94e-12
R03 N02 N03 1.48e-02
C04 N03 N04 8.72e-05
R04 N03 N04 1.57e-02
L05 N04 N05 1.85e-10
R05 N04 N05 6.48e-02
L06 N05 N06 1.30e-10
R06 N05 N06 6.70e-03
C07 N06 N07 1.77e-06
L07 N06 N07 5.04e-11
R07 N06 N07 1.06e-02
C08 N07 N08 3.79e-07
L08 N07 N08 6.45e-11
R08 N07 N08 1.71e-02
C09 N08 N09 4.25e-12
L09 N08 N09 9.65e-10
R09 N08 N09 1.84e+02
C10 N09 N10 8.25e-12
L10 N09 N10 3.93e-10
R10 N09 N10 4.27e+01
C11 N10 Port2 6.63e-11
L11 N10 Port2 3.73e-11
R11 N10 Port2 1.41e+01
.ENDS KR355LD72E684KH01

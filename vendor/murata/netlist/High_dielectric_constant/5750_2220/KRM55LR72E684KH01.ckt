*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-01[uF]/250[V]
* Murata P/N :KRM55LR72E684KH01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72E684KH01 Port1 Port2
C01 Port1 N01 6.72e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 5.30e-12
R03 N02 N03 1.46e-02
C04 N03 N04 7.09e-05
R04 N03 N04 1.51e-02
L05 N04 N05 3.59e-10
R05 N04 N05 5.20e-02
L06 N05 N06 1.39e-11
R06 N05 N06 2.13e-02
L07 N06 N07 2.72e-10
R07 N06 N07 4.07e-03
C08 N07 N08 8.80e-06
L08 N07 N08 1.09e-11
R08 N07 N08 6.20e-03
C09 N08 N09 3.90e-12
L09 N08 N09 1.10e-09
R09 N08 N09 2.26e+02
C10 N09 Port2 9.27e-12
L10 N09 Port2 3.34e-10
R10 N09 Port2 2.43e+01
.ENDS KRM55LR72E684KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :GR355DD72J104KW01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355DD72J104KW01 Port1 Port2
C01 Port1 N01 1.03e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 2.43e-10
R03 N02 N03 1.32e-02
C04 N03 N04 2.98e-05
R04 N03 N04 1.20e+02
C05 N04 N05 4.76e-05
R05 N04 N05 9.70e+00
C06 N05 N06 4.74e-05
R06 N05 N06 1.86e+00
C07 N06 N07 4.41e-05
R07 N06 N07 3.85e-01
C08 N07 N08 3.99e-05
R08 N07 N08 8.13e-02
C09 N08 N09 2.43e-05
R09 N08 N09 1.82e-02
L10 N09 N10 4.51e-11
R10 N09 N10 5.29e-02
L11 N10 N11 6.51e-11
R11 N10 N11 3.65e-02
C12 N11 N12 2.42e-07
L12 N11 N12 4.39e-11
R12 N11 N12 5.07e-02
C13 N12 N13 8.26e-08
L13 N12 N13 3.76e-11
R13 N12 N13 4.11e-02
C14 N13 Port2 9.84e-12
L14 N13 Port2 4.61e-10
R14 N13 Port2 4.52e+01
.ENDS GR355DD72J104KW01

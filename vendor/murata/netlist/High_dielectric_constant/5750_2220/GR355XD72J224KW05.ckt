*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :GR355XD72J224KW05
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355XD72J224KW05 Port1 Port2
C01 Port1 N01 2.21e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.99e-10
R03 N02 N03 6.78e-03
C04 N03 N04 9.39e-05
R04 N03 N04 2.93e+01
C05 N04 N05 1.25e-04
R05 N04 N05 4.43e+00
C06 N05 N06 1.14e-04
R06 N05 N06 9.88e-01
C07 N06 N07 1.06e-04
R07 N06 N07 2.10e-01
C08 N07 N08 9.76e-05
R08 N07 N08 4.44e-02
C09 N08 N09 6.83e-05
R09 N08 N09 8.90e-03
L10 N09 N10 4.83e-11
R10 N09 N10 4.53e-02
L11 N10 N11 9.49e-11
R11 N10 N11 3.72e-02
L12 N11 N12 4.03e-11
R12 N11 N12 1.42e-02
C13 N12 N13 3.72e-07
L13 N12 N13 1.10e-10
R13 N12 N13 9.90e-02
C14 N13 N14 1.85e-07
L14 N13 N14 7.84e-11
R14 N13 N14 7.36e-02
C15 N14 Port2 1.24e-11
L15 N14 Port2 3.21e-10
R15 N14 Port2 3.83e+01
.ENDS GR355XD72J224KW05

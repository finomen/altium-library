*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e+00[uF]/100[V]
* Murata P/N :KRM55LR72A475KH01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72A475KH01 Port1 Port2
C01 Port1 N01 4.59e-06
R01 Port1 N01 2.13e+07
L02 N01 N02 4.86e-11
R03 N02 N03 7.62e-03
C04 N03 N04 4.86e-04
R04 N03 N04 2.31e+00
C05 N04 N05 5.54e-04
R05 N04 N05 1.92e-01
C06 N05 N06 4.76e-04
R06 N05 N06 1.96e-02
L07 N06 N07 7.57e-11
R07 N06 N07 9.64e-02
L08 N07 N08 3.05e-10
R08 N07 N08 2.73e-02
L09 N08 N09 4.94e-10
R09 N08 N09 7.41e-03
C10 N09 N10 1.01e-05
L10 N09 N10 8.01e-11
R10 N09 N10 7.86e-03
C11 N10 N11 5.18e-06
L11 N10 N11 5.60e-11
R11 N10 N11 7.06e-03
C12 N11 Port2 2.99e-12
L12 N11 Port2 1.28e-09
R12 N11 Port2 7.07e+02
.ENDS KRM55LR72A475KH01

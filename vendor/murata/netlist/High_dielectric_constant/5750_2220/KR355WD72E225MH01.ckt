*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e+00[uF]/250[V]
* Murata P/N :KR355WD72E225MH01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355WD72E225MH01 Port1 Port2
C01 Port1 N01 1.99e-06
R01 Port1 N01 4.55e+07
L02 N01 N02 1.06e-11
R03 N02 N03 4.76e-03
C04 N03 N04 9.56e-04
R04 N03 N04 9.51e-02
C05 N04 N05 8.89e-04
R05 N04 N05 1.73e-02
C06 N05 N06 1.57e-03
R06 N05 N06 1.27e-03
L07 N06 N07 4.19e-10
R07 N06 N07 5.25e-02
L08 N07 N08 1.16e-11
R08 N07 N08 3.31e-02
L09 N08 N09 1.02e-09
R09 N08 N09 6.59e-03
C10 N09 N10 3.44e-06
L10 N09 N10 3.07e-10
R10 N09 N10 6.54e-02
C11 N10 N11 3.12e-06
L11 N10 N11 9.97e-11
R11 N10 N11 4.51e-02
C12 N11 N12 5.71e-06
L12 N11 N12 3.27e-11
R12 N11 N12 1.94e-02
C13 N12 N13 2.16e-06
L13 N12 N13 4.29e-11
R13 N12 N13 1.72e-02
C14 N13 N14 4.81e-12
L14 N13 N14 7.30e-10
R14 N13 N14 1.47e+02
C15 N14 Port2 6.17e-12
L15 N14 Port2 4.66e-10
R15 N14 Port2 8.41e+01
.ENDS KR355WD72E225MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :KR355QD72J224KH01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355QD72J224KH01 Port1 Port2
C01 Port1 N01 2.20e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 3.16e-11
R03 N02 N03 1.23e-02
C04 N03 N04 5.82e-05
R04 N03 N04 3.62e-02
L05 N04 N05 2.58e-10
R05 N04 N05 9.33e-02
L06 N05 N06 7.75e-12
R06 N05 N06 6.21e-02
L07 N06 N07 3.11e-10
R07 N06 N07 7.19e-03
C08 N07 N08 6.95e-07
L08 N07 N08 6.63e-11
R08 N07 N08 6.11e-02
C09 N08 N09 2.68e-07
L09 N08 N09 5.79e-11
R09 N08 N09 4.99e-02
C10 N09 N10 6.06e-12
L10 N09 N10 7.62e-10
R10 N09 N10 1.45e+02
C11 N10 Port2 5.82e-12
L11 N10 Port2 5.23e-10
R11 N10 Port2 6.67e+01
.ENDS KR355QD72J224KH01

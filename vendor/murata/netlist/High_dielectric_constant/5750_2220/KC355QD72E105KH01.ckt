*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :KC355QD72E105KH01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 10[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355QD72E105KH01 Port1 Port2
C01 Port1 N01 9.83e-07
R01 Port1 N01 1.00e+08
L02 N01 N02 9.07e-11
R03 N02 N03 5.49e-03
C04 N03 N04 3.96e-04
R04 N03 N04 8.74e-02
C05 N04 N05 3.45e-04
R05 N04 N05 9.28e-03
L06 N05 N06 2.99e-11
R06 N05 N06 1.86e-01
L07 N06 N07 1.62e-10
R07 N06 N07 8.10e-02
L08 N07 N08 4.14e-10
R08 N07 N08 4.58e-03
L09 N08 N09 6.14e-10
R09 N08 N09 2.61e-03
C10 N09 N10 2.22e-06
L10 N09 N10 1.19e-10
R10 N09 N10 4.29e-02
C11 N10 N11 1.24e-06
L11 N10 N11 7.72e-11
R11 N10 N11 3.79e-02
C12 N11 N12 1.45e-07
L12 N11 N12 1.80e-10
R12 N11 N12 2.92e-02
C13 N12 Port2 3.51e-12
L13 N12 Port2 1.12e-09
R13 N12 Port2 5.21e+02
.ENDS KC355QD72E105KH01

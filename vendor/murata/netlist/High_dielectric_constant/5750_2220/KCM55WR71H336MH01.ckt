*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e+01[uF]/50[V]
* Murata P/N :KCM55WR71H336MH01
* Property : C = 3.30e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55WR71H336MH01 Port1 Port2
C01 Port1 N01 3.34e-05
R01 Port1 N01 3.03e+06
L02 N01 N02 1.35e-11
R03 N02 N03 5.07e-03
C04 N03 N04 4.19e-03
R04 N03 N04 2.44e-01
C05 N04 N05 3.61e-03
R05 N04 N05 3.43e-02
C06 N05 N06 4.22e-03
R06 N05 N06 3.40e-03
L07 N06 N07 3.24e-11
R07 N06 N07 1.80e-01
L08 N07 N08 1.33e-10
R08 N07 N08 3.92e-02
L09 N08 N09 9.19e-10
R09 N08 N09 1.84e-02
L10 N09 N10 9.50e-10
R10 N09 N10 3.81e-03
C11 N10 N11 5.94e-05
L11 N10 N11 3.39e-10
R11 N10 N11 7.95e-03
C12 N11 N12 7.08e-05
L12 N11 N12 9.09e-11
R12 N11 N12 6.10e-03
C13 N12 Port2 2.89e-12
L13 N12 Port2 1.17e-09
R13 N12 Port2 8.80e+02
.ENDS KCM55WR71H336MH01

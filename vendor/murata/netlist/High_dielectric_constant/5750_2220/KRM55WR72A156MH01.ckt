*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e+01[uF]/100[V]
* Murata P/N :KRM55WR72A156MH01
* Property : C = 1.50e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55WR72A156MH01 Port1 Port2
C01 Port1 N01 1.39e-05
R01 Port1 N01 6.67e+06
L02 N01 N02 1.77e-11
R03 N02 N03 3.63e-03
C04 N03 N04 2.04e-03
R04 N03 N04 4.36e-01
C05 N04 N05 1.49e-03
R05 N04 N05 6.00e-02
C06 N05 N06 2.05e-03
R06 N05 N06 4.07e-03
L07 N06 N07 1.48e-11
R07 N06 N07 1.01e-01
L08 N07 N08 9.92e-11
R08 N07 N08 7.37e-02
L09 N08 N09 6.33e-10
R09 N08 N09 2.36e-02
L10 N09 N10 7.01e-10
R10 N09 N10 3.94e-03
C11 N10 N11 2.47e-05
L11 N10 N11 2.93e-10
R11 N10 N11 1.37e-02
C12 N11 N12 1.13e-05
L12 N11 N12 1.50e-10
R12 N11 N12 6.74e-03
C13 N12 Port2 3.19e-12
L13 N12 Port2 1.14e-09
R13 N12 Port2 5.19e+02
.ENDS KRM55WR72A156MH01

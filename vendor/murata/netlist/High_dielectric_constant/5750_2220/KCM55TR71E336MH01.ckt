*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e+01[uF]/25[V]
* Murata P/N :KCM55TR71E336MH01
* Property : C = 3.30e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55TR71E336MH01 Port1 Port2
C01 Port1 N01 2.95e-05
R01 Port1 N01 3.03e+06
L02 N01 N02 1.67e-11
R03 N02 N03 4.82e-03
C04 N03 N04 4.18e-03
R04 N03 N04 2.34e-01
C05 N04 N05 2.90e-03
R05 N04 N05 3.80e-02
C06 N05 N06 3.78e-03
R06 N05 N06 2.14e-03
L07 N06 N07 1.28e-11
R07 N06 N07 9.42e-02
L08 N07 N08 1.02e-10
R08 N07 N08 5.09e-02
L09 N08 N09 7.79e-10
R09 N08 N09 2.20e-02
L10 N09 N10 7.51e-10
R10 N09 N10 2.75e-03
C11 N10 N11 6.53e-05
L11 N10 N11 2.20e-10
R11 N10 N11 6.34e-03
C12 N11 N12 2.51e-05
L12 N11 N12 1.49e-10
R12 N11 N12 4.69e-03
C13 N12 Port2 2.87e-12
L13 N12 Port2 1.13e-09
R13 N12 Port2 5.12e+02
.ENDS KCM55TR71E336MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.70e+01[uF]/50[V]
* Murata P/N :KCM55QR71H176KH01
* Property : C = 1.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55QR71H176KH01 Port1 Port2
C01 Port1 N01 1.71e-05
R01 Port1 N01 5.88e+06
L02 N01 N02 3.25e-11
R03 N02 N03 3.72e-03
C04 N03 N04 2.17e-03
R04 N03 N04 4.12e-01
C05 N04 N05 1.88e-03
R05 N04 N05 5.93e-02
C06 N05 N06 2.29e-03
R06 N05 N06 5.92e-03
L07 N06 N07 7.22e-11
R07 N06 N07 6.51e-02
L08 N07 N08 5.32e-10
R08 N07 N08 2.61e-02
L09 N08 N09 7.95e-10
R09 N08 N09 3.84e-03
C10 N09 N10 3.37e-05
L10 N09 N10 1.59e-10
R10 N09 N10 6.07e-03
C11 N10 N11 8.72e-06
L11 N10 N11 2.17e-10
R11 N10 N11 9.14e-03
C12 N11 Port2 2.90e-12
L12 N11 Port2 1.08e-09
R12 N11 Port2 1.15e+03
.ENDS KCM55QR71H176KH01

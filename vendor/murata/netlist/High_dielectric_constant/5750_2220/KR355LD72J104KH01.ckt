*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.00e-01[uF]/630[V]
* Murata P/N :KR355LD72J104KH01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD72J104KH01 Port1 Port2
C01 Port1 N01 9.69e-08
R01 Port1 N01 1.00e+09
L02 N01 N02 2.61e-12
R03 N02 N03 4.82e-04
C04 N03 N04 1.32e-05
R04 N03 N04 5.97e-02
L05 N04 N05 1.41e-10
R05 N04 N05 1.99e-02
L06 N05 N06 6.71e-09
R06 N05 N06 1.92e-02
C07 N06 N07 3.45e-07
L07 N06 N07 3.52e-11
R07 N06 N07 4.31e-02
C08 N07 N08 6.76e-08
L08 N07 N08 5.10e-11
R08 N07 N08 5.21e-02
C09 N08 N09 1.20e-08
L09 N08 N09 4.98e-11
R09 N08 N09 5.28e-02
C10 N09 N10 5.31e-12
L10 N09 N10 1.01e-09
R10 N09 N10 1.49e+02
C11 N10 N11 6.77e-12
L11 N10 N11 4.71e-10
R11 N10 N11 5.44e+01
C12 N11 Port2 1.58e-11
L12 N11 Port2 5.89e-11
R12 N11 Port2 5.64e+00
.ENDS KR355LD72J104KH01

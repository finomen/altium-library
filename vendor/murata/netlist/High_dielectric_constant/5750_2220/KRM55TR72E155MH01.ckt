*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e+00[uF]/250[V]
* Murata P/N :KRM55TR72E155MH01
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR72E155MH01 Port1 Port2
C01 Port1 N01 1.37e-06
R01 Port1 N01 6.67e+07
L02 N01 N02 1.17e-11
R03 N02 N03 1.03e-02
C04 N03 N04 1.87e-04
R04 N03 N04 3.62e+00
C05 N04 N05 1.76e-04
R05 N04 N05 3.65e-01
C06 N05 N06 1.67e-04
R06 N05 N06 3.98e-02
C07 N06 N07 3.55e-04
R07 N06 N07 3.29e-03
L08 N07 N08 2.42e-10
R08 N07 N08 6.15e-02
L09 N08 N09 7.14e-12
R09 N08 N09 3.46e-02
L10 N09 N10 3.48e-10
R10 N09 N10 8.82e-03
C11 N10 N11 3.09e-06
L11 N10 N11 1.71e-10
R11 N10 N11 2.47e-02
C12 N11 N12 7.60e-07
L12 N11 N12 1.07e-10
R12 N11 N12 1.78e-02
C13 N12 Port2 2.99e-12
L13 N12 Port2 1.27e-09
R13 N12 Port2 1.77e+02
.ENDS KRM55TR72E155MH01

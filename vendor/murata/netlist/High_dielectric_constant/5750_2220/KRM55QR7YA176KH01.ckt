*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.70e+01[uF]/35[V]
* Murata P/N :KRM55QR7YA176KH01
* Property : C = 1.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QR7YA176KH01 Port1 Port2
C01 Port1 N01 1.68e-05
R01 Port1 N01 5.88e+06
L02 N01 N02 1.30e-11
R03 N02 N03 4.74e-03
C04 N03 N04 1.89e-03
R04 N03 N04 6.80e-01
C05 N04 N05 1.80e-03
R05 N04 N05 6.03e-02
C06 N05 N06 1.82e-03
R06 N05 N06 4.08e-03
L07 N06 N07 1.82e-11
R07 N06 N07 1.70e-01
L08 N07 N08 9.12e-11
R08 N07 N08 5.88e-02
L09 N08 N09 6.08e-10
R09 N08 N09 2.37e-02
L10 N09 N10 7.85e-10
R10 N09 N10 4.01e-03
C11 N10 N11 3.52e-05
L11 N10 N11 1.51e-10
R11 N10 N11 6.22e-03
C12 N11 N12 1.23e-05
L12 N11 N12 1.59e-10
R12 N11 N12 9.03e-03
C13 N12 Port2 2.80e-12
L13 N12 Port2 1.12e-09
R13 N12 Port2 8.88e+02
.ENDS KRM55QR7YA176KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-01[uF]/250[V]
* Murata P/N :GCJ55DR72E684KXJ1
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E684KXJ1 Port1 Port2
C01 Port1 N01 7.15e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 2.49e-10
R03 N02 N03 8.97e-03
C04 N03 N04 7.19e-05
R04 N03 N04 2.70e+01
C05 N04 N05 6.69e-05
R05 N04 N05 8.79e+00
C06 N05 N06 5.93e-05
R06 N05 N06 1.73e+00
C07 N06 N07 5.78e-05
R07 N06 N07 4.10e-01
C08 N07 N08 7.96e-05
R08 N07 N08 4.82e-02
C09 N08 N09 6.47e-05
R09 N08 N09 1.05e-02
L10 N09 N10 3.77e-11
R10 N09 N10 1.91e-01
L11 N10 N11 7.60e-11
R11 N10 N11 2.53e-02
L12 N11 N12 1.09e-10
R12 N11 N12 2.25e-02
C13 N12 N13 1.53e-06
L13 N12 N13 5.36e-11
R13 N12 N13 1.85e-02
C14 N13 N14 7.88e-07
L14 N13 N14 3.19e-11
R14 N13 N14 1.36e-02
C15 N14 Port2 9.33e-12
L15 N14 Port2 3.21e-10
R15 N14 Port2 6.14e+01
.ENDS GCJ55DR72E684KXJ1

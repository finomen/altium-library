*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e+00[uF]/250[V]
* Murata P/N :KRM55TR72E225MH01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR72E225MH01 Port1 Port2
C01 Port1 N01 1.97e-06
R01 Port1 N01 4.55e+07
L02 N01 N02 1.60e-11
R03 N02 N03 7.47e-03
C04 N03 N04 3.45e-04
R04 N03 N04 6.00e-01
C05 N04 N05 3.01e-04
R05 N04 N05 1.02e-01
C06 N05 N06 5.55e-04
R06 N05 N06 1.18e-02
C07 N06 N07 3.65e-04
R07 N06 N07 5.01e-03
L08 N07 N08 5.47e-11
R08 N07 N08 1.04e-01
L09 N08 N09 4.14e-10
R09 N08 N09 4.66e-02
L10 N09 N10 2.74e-10
R10 N09 N10 5.09e-03
C11 N10 N11 4.06e-06
L11 N10 N11 1.89e-10
R11 N10 N11 3.51e-02
C12 N11 N12 1.98e-06
L12 N11 N12 9.76e-11
R12 N11 N12 1.78e-02
C13 N12 Port2 3.04e-12
L13 N12 Port2 1.09e-09
R13 N12 Port2 4.15e+02
.ENDS KRM55TR72E225MH01

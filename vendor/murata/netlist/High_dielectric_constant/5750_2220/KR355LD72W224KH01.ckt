*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e-01[uF]/450[V]
* Murata P/N :KR355LD72W224KH01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD72W224KH01 Port1 Port2
C01 Port1 N01 2.19e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 1.75e-12
R03 N02 N03 2.55e-03
C04 N03 N04 2.58e-05
R04 N03 N04 2.91e-02
L05 N04 N05 8.11e-11
R05 N04 N05 8.97e-02
L06 N05 N06 1.50e-10
R06 N05 N06 1.44e-02
L07 N06 N07 4.60e-09
R07 N06 N07 1.42e-02
C08 N07 N08 1.03e-06
L08 N07 N08 2.63e-11
R08 N07 N08 1.95e-02
C09 N08 N09 9.78e-08
L09 N08 N09 7.15e-11
R09 N08 N09 4.07e-02
C10 N09 N10 7.19e-12
L10 N09 N10 7.93e-10
R10 N09 N10 1.11e+02
C11 N10 Port2 4.53e-12
L11 N10 Port2 6.82e-10
R11 N10 Port2 1.09e+02
.ENDS KR355LD72W224KH01

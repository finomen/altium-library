*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.30e-01[uF]/1250[V]
* Murata P/N :KC355QD7LG134KH01
* Property : C = 1.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355QD7LG134KH01 Port1 Port2
C01 Port1 N01 1.29e-07
L02 N01 N02 3.03e-10
R03 N02 N03 1.20e-02
C04 N03 N04 2.89e-05
R04 N03 N04 5.01e-02
L05 N04 N05 1.83e-10
R05 N04 N05 9.12e-02
L06 N05 N06 3.95e-12
R06 N05 N06 2.51e-02
L07 N06 N07 2.98e-10
R07 N06 N07 8.91e-03
C08 N07 N08 3.12e-07
L08 N07 N08 1.05e-10
R08 N07 N08 1.59e-01
C09 N08 N09 1.53e-07
L09 N08 N09 7.80e-11
R09 N08 N09 1.62e-01
C10 N09 N10 2.84e-07
L10 N09 N10 1.95e-11
R10 N09 N10 2.45e-02
C11 N10 N11 2.09e-07
L11 N10 N11 1.55e-11
R11 N10 N11 3.92e-02
C12 N11 Port2 4.05e-12
L12 N11 Port2 9.63e-10
R12 N11 Port2 2.03e+02
.ENDS KC355QD7LG134KH01

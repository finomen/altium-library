*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/5.60e-01[uF]/630[V]
* Murata P/N :GC355XD7LQ564KX17
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC355XD7LQ564KX17 Port1 Port2
C01 Port1 N01 5.67e-07
R01 Port1 N01 1.79e+08
L02 N01 N02 1.94e-10
R03 N02 N03 3.72e-03
C04 N03 N04 2.06e-04
R04 N03 N04 2.20e+01
C05 N04 N05 2.90e-04
R05 N04 N05 2.49e+00
C06 N05 N06 2.97e-04
R06 N05 N06 5.12e-01
C07 N06 N07 2.74e-04
R07 N06 N07 1.24e-01
C08 N07 N08 3.01e-04
R08 N07 N08 2.55e-02
C09 N08 N09 1.72e-04
R09 N08 N09 7.22e-03
L10 N09 N10 5.24e-11
R10 N09 N10 2.44e-02
L11 N10 N11 9.10e-11
R11 N10 N11 2.24e-02
L12 N11 N12 5.63e-11
R12 N11 N12 1.83e-02
C13 N12 N13 1.08e-06
L13 N12 N13 1.25e-10
R13 N12 N13 8.30e-02
C14 N13 N14 6.05e-07
L14 N13 N14 8.28e-11
R14 N13 N14 6.52e-02
C15 N14 N15 6.98e-10
L15 N14 N15 1.07e-11
R15 N14 N15 1.45e-01
C16 N15 Port2 1.04e-11
L16 N15 Port2 2.77e-10
R16 N15 Port2 4.56e+01
.ENDS GC355XD7LQ564KX17

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/5.60e-01[uF]/450[V]
* Murata P/N :KC355LD7LP564KV01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355LD7LP564KV01 Port1 Port2
C01 Port1 N01 5.71e-07
L02 N01 N02 1.69e-10
R03 N02 N03 7.28e-03
C04 N03 N04 1.82e-04
R04 N03 N04 7.94e-03
L05 N04 N05 3.17e-10
R05 N04 N05 5.89e-02
L06 N05 N06 4.47e-12
R06 N05 N06 7.67e-03
L07 N06 N07 6.31e-10
R07 N06 N07 5.82e-03
C08 N07 N08 2.22e-06
L08 N07 N08 4.85e-11
R08 N07 N08 3.05e-02
C09 N08 N09 7.93e-07
L09 N08 N09 4.68e-11
R09 N08 N09 3.33e-02
C10 N09 Port2 3.76e-12
L10 N09 Port2 1.12e-09
R10 N09 Port2 2.46e+02
.ENDS KC355LD7LP564KV01

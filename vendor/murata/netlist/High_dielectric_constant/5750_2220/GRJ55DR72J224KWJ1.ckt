*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :GRJ55DR72J224KWJ1
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72J224KWJ1 Port1 Port2
C01 Port1 N01 2.33e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.70e-10
R03 N02 N03 9.98e-03
C04 N03 N04 2.69e-05
R04 N03 N04 7.49e+01
C05 N04 N05 3.07e-05
R05 N04 N05 1.48e+01
C06 N05 N06 2.59e-05
R06 N05 N06 3.32e+00
C07 N06 N07 2.29e-05
R07 N06 N07 6.89e-01
C08 N07 N08 2.63e-05
R08 N07 N08 1.16e-01
C09 N08 N09 1.77e-05
R09 N08 N09 2.49e-02
L10 N09 N10 1.96e-11
R10 N09 N10 1.45e-01
L11 N10 N11 1.29e-10
R11 N10 N11 8.53e-02
C12 N11 N12 3.97e-07
L12 N11 N12 9.96e-11
R12 N11 N12 8.26e-02
C13 N12 N13 1.18e-07
L13 N12 N13 1.11e-10
R13 N12 N13 6.85e-02
C14 N13 Port2 1.46e-11
L14 N13 Port2 1.43e-10
R14 N13 Port2 1.85e+01
.ENDS GRJ55DR72J224KWJ1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/5.60e-01[uF]/250[V]
* Murata P/N :KR355LD72E564KH01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD72E564KH01 Port1 Port2
C01 Port1 N01 5.76e-07
L02 N01 N02 5.70e-13
R03 N02 N03 7.63e-03
C04 N03 N04 2.09e-04
R04 N03 N04 6.92e-03
L05 N04 N05 2.85e-10
R05 N04 N05 6.03e-02
L06 N05 N06 6.75e-10
R06 N05 N06 6.92e-03
C07 N06 N07 1.74e-06
L07 N06 N07 6.14e-11
R07 N06 N07 2.93e-02
C08 N07 N08 6.11e-07
L08 N07 N08 5.62e-11
R08 N07 N08 3.07e-02
C09 N08 N09 5.26e-12
L09 N08 N09 8.39e-10
R09 N08 N09 1.65e+02
C10 N09 N10 4.81e-11
L10 N09 N10 8.48e-11
R10 N09 N10 1.85e+02
C11 N10 N11 1.87e-11
L11 N10 N11 1.99e-10
R11 N10 N11 4.55e+01
C12 N11 Port2 1.52e-11
L12 N11 Port2 2.04e-10
R12 N11 Port2 4.05e+01
.ENDS KR355LD72E564KH01

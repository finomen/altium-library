*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-02[uF]/1000[V]
* Murata P/N :GCJ55DR73A683KXJ1
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR73A683KXJ1 Port1 Port2
C01 Port1 N01 7.03e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 1.80e-10
R03 N02 N03 2.26e-02
C04 N03 N04 9.73e-06
R04 N03 N04 2.32e+02
C05 N04 N05 1.04e-05
R05 N04 N05 5.29e+01
C06 N05 N06 9.29e-06
R06 N05 N06 1.17e+01
C07 N06 N07 8.78e-06
R07 N06 N07 2.50e+00
C08 N07 N08 7.86e-06
R08 N07 N08 5.80e-01
C09 N08 N09 7.28e-06
R09 N08 N09 1.07e-01
C10 N09 N10 4.79e-06
R10 N09 N10 2.70e-02
L11 N10 N11 1.55e-11
R11 N10 N11 6.62e-02
L12 N11 N12 6.98e-11
R12 N11 N12 6.34e-02
C13 N12 N13 1.63e-07
L13 N12 N13 4.15e-11
R13 N12 N13 5.84e-02
C14 N13 N14 5.60e-08
L14 N13 N14 3.48e-11
R14 N13 N14 5.04e-02
C15 N14 Port2 7.05e-12
L15 N14 Port2 5.07e-10
R15 N14 Port2 5.06e+01
.ENDS GCJ55DR73A683KXJ1

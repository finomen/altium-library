*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/4.70e-01[uF]/450[V]
* Murata P/N :GC355DD7LP474KX18
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GC355DD7LP474KX18 Port1 Port2
C01 Port1 N01 4.68e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 2.50e-10
R03 N02 N03 4.37e-03
C04 N03 N04 1.39e-04
R04 N03 N04 3.20e+01
C05 N04 N05 2.25e-04
R05 N04 N05 2.43e+00
C06 N05 N06 2.43e-04
R06 N05 N06 4.52e-01
C07 N06 N07 2.26e-04
R07 N06 N07 1.21e-01
C08 N07 N08 1.07e-04
R08 N07 N08 3.73e-02
C09 N08 N09 2.12e-04
R09 N08 N09 3.92e-03
L10 N09 N10 8.15e-11
R10 N09 N10 3.71e-02
L11 N10 N11 6.54e-11
R11 N10 N11 2.46e-02
L12 N11 N12 5.10e-11
R12 N11 N12 1.27e-02
C13 N12 N13 8.36e-07
L13 N12 N13 1.06e-10
R13 N12 N13 8.54e-02
C14 N13 N14 4.54e-07
L14 N13 N14 7.18e-11
R14 N13 N14 6.01e-02
C15 N14 Port2 1.49e-11
L15 N14 Port2 1.42e-10
R15 N14 Port2 1.36e+01
.ENDS GC355DD7LP474KX18

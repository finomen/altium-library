*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-01[uF]/250[V]
* Murata P/N :GRJ55DR72E334KWJ1
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR72E334KWJ1 Port1 Port2
C01 Port1 N01 3.60e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 1.49e-10
R03 N02 N03 1.17e-02
C04 N03 N04 2.61e-05
R04 N03 N04 2.38e+02
C05 N04 N05 3.18e-05
R05 N04 N05 1.92e+01
C06 N05 N06 3.71e-05
R06 N05 N06 2.65e+00
C07 N06 N07 3.24e-05
R07 N06 N07 5.78e-01
C08 N07 N08 4.12e-05
R08 N07 N08 9.12e-02
C09 N08 N09 2.92e-05
R09 N08 N09 1.81e-02
L10 N09 N10 2.13e-10
R10 N09 N10 3.00e-02
L11 N10 N11 1.43e-10
R11 N10 N11 2.98e-02
C12 N11 Port2 6.39e-12
L12 N11 Port2 5.12e-10
R12 N11 Port2 4.87e+01
.ENDS GRJ55DR72E334KWJ1

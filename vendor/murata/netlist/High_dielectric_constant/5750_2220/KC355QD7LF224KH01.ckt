*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e-01[uF]/1000[V]
* Murata P/N :KC355QD7LF224KH01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355QD7LF224KH01 Port1 Port2
C01 Port1 N01 2.26e-07
L02 N01 N02 3.94e-10
R03 N02 N03 1.02e-02
C04 N03 N04 6.78e-05
R04 N03 N04 2.14e-02
L05 N04 N05 2.05e-12
R05 N04 N05 9.33e-02
L06 N05 N06 3.17e-10
R06 N05 N06 7.76e-02
L07 N06 N07 4.46e-10
R07 N06 N07 7.41e-03
C08 N07 N08 5.72e-07
L08 N07 N08 1.05e-10
R08 N07 N08 1.06e-01
C09 N08 N09 2.83e-07
L09 N08 N09 7.45e-11
R09 N08 N09 1.08e-01
C10 N09 Port2 4.17e-12
L10 N09 Port2 8.93e-10
R10 N09 Port2 2.29e+02
.ENDS KC355QD7LF224KH01

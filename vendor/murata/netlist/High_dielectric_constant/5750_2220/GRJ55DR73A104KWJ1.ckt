*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-01[uF]/1000[V]
* Murata P/N :GRJ55DR73A104KWJ1
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR73A104KWJ1 Port1 Port2
C01 Port1 N01 1.03e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 2.31e-10
R03 N02 N03 1.61e-02
C04 N03 N04 1.23e-05
R04 N03 N04 1.49e+02
C05 N04 N05 1.52e-05
R05 N04 N05 2.24e+01
C06 N05 N06 1.27e-05
R06 N05 N06 4.86e+00
C07 N06 N07 1.12e-05
R07 N06 N07 9.02e-01
C08 N07 N08 1.02e-05
R08 N07 N08 1.70e-01
C09 N08 N09 6.95e-06
R09 N08 N09 2.61e-02
L10 N09 N10 4.77e-11
R10 N09 N10 1.22e-01
L11 N10 N11 1.37e-10
R11 N10 N11 1.13e-01
C12 N11 N12 1.93e-07
L12 N11 N12 7.36e-11
R12 N11 N12 9.15e-02
C13 N12 N13 7.69e-08
L13 N12 N13 5.65e-11
R13 N12 N13 6.95e-02
C14 N13 Port2 9.83e-12
L14 N13 Port2 2.56e-10
R14 N13 Port2 2.97e+01
.ENDS GRJ55DR73A104KWJ1

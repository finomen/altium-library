*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e+00[uF]/100[V]
* Murata P/N :KRM55QR72A685KH01
* Property : C = 6.80e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QR72A685KH01 Port1 Port2
C01 Port1 N01 6.30e-06
R01 Port1 N01 1.47e+07
L02 N01 N02 6.03e-12
R03 N02 N03 5.11e-03
C04 N03 N04 1.29e-03
R04 N03 N04 5.57e-01
C05 N04 N05 7.77e-04
R05 N04 N05 1.27e-01
C06 N05 N06 8.04e-04
R06 N05 N06 1.20e-02
L07 N06 N07 7.07e-11
R07 N06 N07 6.79e-02
L08 N07 N08 5.69e-12
R08 N07 N08 4.29e-02
L09 N08 N09 4.27e-10
R09 N08 N09 3.23e-02
L10 N09 N10 6.28e-10
R10 N09 N10 3.35e-03
C11 N10 N11 1.25e-05
L11 N10 N11 1.29e-10
R11 N10 N11 8.32e-03
C12 N11 N12 4.04e-06
L12 N11 N12 1.34e-10
R12 N11 N12 1.04e-02
C13 N12 Port2 2.84e-12
L13 N12 Port2 1.28e-09
R13 N12 Port2 2.97e+02
.ENDS KRM55QR72A685KH01

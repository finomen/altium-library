*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-01[uF]/450[V]
* Murata P/N :KRM55LR72W334KH01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72W334KH01 Port1 Port2
C01 Port1 N01 3.27e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 3.35e-12
R03 N02 N03 2.14e-02
C04 N03 N04 2.96e-05
R04 N03 N04 4.72e-02
L05 N04 N05 1.07e-10
R05 N04 N05 8.02e-02
L06 N05 N06 1.82e-10
R06 N05 N06 2.16e-02
C07 N06 N07 2.33e-07
L07 N06 N07 6.66e-11
R07 N06 N07 1.68e-02
C08 N07 N08 5.21e-12
L08 N07 N08 9.40e-10
R08 N07 N08 1.22e+02
C09 N08 N09 1.22e-11
L09 N08 N09 3.04e-10
R09 N08 N09 3.59e+01
C10 N09 N10 2.74e-11
L10 N09 N10 1.13e-10
R10 N09 N10 2.21e+01
C11 N10 Port2 4.05e-11
L11 N10 Port2 6.36e-11
R11 N10 Port2 1.14e+01
.ENDS KRM55LR72W334KH01

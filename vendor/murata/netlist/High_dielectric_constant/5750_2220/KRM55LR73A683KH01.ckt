*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-02[uF]/1000[V]
* Murata P/N :KRM55LR73A683KH01
* Property : C = 6.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR73A683KH01 Port1 Port2
C01 Port1 N01 6.78e-08
R01 Port1 N01 1.47e+09
L02 N01 N02 2.22e-12
R03 N02 N03 3.48e-02
C04 N03 N04 5.23e-06
R04 N03 N04 2.51e-01
C05 N04 N05 1.08e-05
R05 N04 N05 1.61e-02
L06 N05 N06 1.41e-10
R06 N05 N06 9.87e-02
L07 N06 N07 1.21e-11
R07 N06 N07 2.25e-03
C08 N07 N08 2.29e-07
L08 N07 N08 3.15e-11
R08 N07 N08 3.59e-02
C09 N08 N09 5.23e-12
L09 N08 N09 9.62e-10
R09 N08 N09 1.04e+02
C10 N09 Port2 6.01e-12
L10 N09 Port2 5.83e-10
R10 N09 Port2 4.13e+01
.ENDS KRM55LR73A683KH01

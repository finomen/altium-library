*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :KRM55TR72J474MH01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR72J474MH01 Port1 Port2
C01 Port1 N01 4.29e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 1.04e-11
R03 N02 N03 1.30e-02
C04 N03 N04 3.78e-05
R04 N03 N04 4.23e-02
L05 N04 N05 5.15e-12
R05 N04 N05 1.04e-01
L06 N05 N06 2.23e-10
R06 N05 N06 7.58e-02
L07 N06 N07 9.02e-11
R07 N06 N07 3.00e-03
C08 N07 N08 7.79e-07
L08 N07 N08 2.12e-10
R08 N07 N08 9.52e-02
C09 N08 N09 5.54e-07
L09 N08 N09 7.95e-11
R09 N08 N09 4.62e-02
C10 N09 N10 1.66e-06
L10 N09 N10 1.67e-11
R10 N09 N10 2.02e-02
C11 N10 N11 2.22e-07
L11 N10 N11 5.28e-11
R11 N10 N11 2.78e-02
C12 N11 Port2 2.79e-12
L12 N11 Port2 1.17e-09
R12 N11 Port2 3.20e+02
.ENDS KRM55TR72J474MH01

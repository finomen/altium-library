*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :GCJ55DR72E105KXJ1
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCJ55DR72E105KXJ1 Port1 Port2
C01 Port1 N01 1.02e-06
R01 Port1 N01 1.00e+08
L02 N01 N02 2.87e-10
R03 N02 N03 7.03e-03
C04 N03 N04 1.37e-04
R04 N03 N04 1.56e+01
C05 N04 N05 1.15e-04
R05 N04 N05 6.04e+00
C06 N05 N06 9.99e-05
R06 N05 N06 1.20e+00
C07 N06 N07 1.07e-04
R07 N06 N07 2.71e-01
C08 N07 N08 1.37e-04
R08 N07 N08 4.10e-02
C09 N08 N09 9.35e-05
R09 N08 N09 1.29e-02
L10 N09 N10 2.87e-11
R10 N09 N10 2.56e-01
L11 N10 N11 3.48e-11
R11 N10 N11 3.35e-02
L12 N11 N12 1.86e-10
R12 N11 N12 3.34e-02
C13 N12 N13 1.95e-06
L13 N12 N13 8.29e-11
R13 N12 N13 1.93e-02
C14 N13 N14 9.39e-07
L14 N13 N14 5.32e-11
R14 N13 N14 1.52e-02
C15 N14 Port2 1.40e-11
L15 N14 Port2 1.69e-10
R15 N14 Port2 2.99e+01
.ENDS GCJ55DR72E105KXJ1

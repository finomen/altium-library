*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e+00[uF]/63[V]
* Murata P/N :KRM55LR71J475KH01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR71J475KH01 Port1 Port2
C01 Port1 N01 4.80e-06
R01 Port1 N01 2.13e+07
L02 N01 N02 1.43e-11
R03 N02 N03 6.31e-03
C04 N03 N04 6.69e-04
R04 N03 N04 6.12e-01
C05 N04 N05 6.19e-04
R05 N04 N05 9.94e-02
C06 N05 N06 6.30e-04
R06 N05 N06 1.05e-02
L07 N06 N07 5.83e-11
R07 N06 N07 8.65e-02
L08 N07 N08 3.31e-10
R08 N07 N08 3.59e-02
L09 N08 N09 5.98e-10
R09 N08 N09 6.11e-03
C10 N09 N10 8.51e-06
L10 N09 N10 1.04e-10
R10 N09 N10 8.75e-03
C11 N10 N11 3.04e-06
L11 N10 N11 8.66e-11
R11 N10 N11 8.93e-03
C12 N11 Port2 3.14e-12
L12 N11 Port2 1.23e-09
R12 N11 Port2 6.11e+02
.ENDS KRM55LR71J475KH01

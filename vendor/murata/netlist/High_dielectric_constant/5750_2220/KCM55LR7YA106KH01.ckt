*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+01[uF]/35[V]
* Murata P/N :KCM55LR7YA106KH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55LR7YA106KH01 Port1 Port2
C01 Port1 N01 9.83e-06
R01 Port1 N01 1.00e+07
L02 N01 N02 2.25e-10
R03 N02 N03 5.39e-03
C04 N03 N04 1.13e-03
R04 N03 N04 1.03e+00
C05 N04 N05 1.20e-03
R05 N04 N05 1.07e-01
C06 N05 N06 1.09e-03
R06 N05 N06 1.14e-02
L07 N06 N07 5.99e-12
R07 N06 N07 4.37e-01
L08 N07 N08 8.02e-11
R08 N07 N08 6.98e-02
L09 N08 N09 4.03e-10
R09 N08 N09 2.75e-02
L10 N09 N10 9.47e-10
R10 N09 N10 4.81e-03
C11 N10 N11 2.52e-05
L11 N10 N11 8.28e-11
R11 N10 N11 5.58e-03
C12 N11 N12 4.54e-06
L12 N11 N12 1.47e-10
R12 N11 N12 9.58e-03
C13 N12 Port2 3.44e-12
L13 N12 Port2 1.06e-09
R13 N12 Port2 6.19e+02
.ENDS KCM55LR7YA106KH01

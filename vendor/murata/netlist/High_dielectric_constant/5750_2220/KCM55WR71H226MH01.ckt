*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e+01[uF]/50[V]
* Murata P/N :KCM55WR71H226MH01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55WR71H226MH01 Port1 Port2
C01 Port1 N01 1.97e-05
R01 Port1 N01 4.55e+06
L02 N01 N02 1.08e-11
R03 N02 N03 3.05e-03
C04 N03 N04 3.04e-03
R04 N03 N04 4.25e-01
C05 N04 N05 1.96e-03
R05 N04 N05 5.94e-02
C06 N05 N06 2.21e-03
R06 N05 N06 4.23e-03
L07 N06 N07 1.54e-11
R07 N06 N07 1.16e-01
L08 N07 N08 1.06e-10
R08 N07 N08 5.91e-02
L09 N08 N09 7.34e-10
R09 N08 N09 2.11e-02
L10 N09 N10 1.30e-09
R10 N09 N10 3.51e-03
C11 N10 N11 4.04e-05
L11 N10 N11 2.68e-10
R11 N10 N11 1.36e-02
C12 N11 N12 1.64e-05
L12 N11 N12 1.61e-10
R12 N11 N12 6.28e-03
C13 N12 Port2 2.80e-12
L13 N12 Port2 1.25e-09
R13 N12 Port2 4.44e+02
.ENDS KCM55WR71H226MH01

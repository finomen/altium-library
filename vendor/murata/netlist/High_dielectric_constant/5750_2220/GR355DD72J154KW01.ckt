*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :GR355DD72J154KW01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355DD72J154KW01 Port1 Port2
C01 Port1 N01 1.55e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 2.47e-10
R03 N02 N03 9.05e-03
C04 N03 N04 6.29e-05
R04 N03 N04 4.21e+01
C05 N04 N05 8.51e-05
R05 N04 N05 6.20e+00
C06 N05 N06 7.69e-05
R06 N05 N06 1.37e+00
C07 N06 N07 7.32e-05
R07 N06 N07 2.83e-01
C08 N07 N08 6.79e-05
R08 N07 N08 6.23e-02
C09 N08 N09 4.53e-05
R09 N08 N09 1.37e-02
L10 N09 N10 4.29e-11
R10 N09 N10 5.92e-02
L11 N10 N11 8.94e-11
R11 N10 N11 4.32e-02
L12 N11 N12 2.15e-11
R12 N11 N12 1.01e-02
C13 N12 N13 3.42e-07
L13 N12 N13 6.45e-11
R13 N12 N13 7.64e-02
C14 N13 N14 1.20e-07
L14 N13 N14 6.02e-11
R14 N13 N14 5.53e-02
C15 N14 Port2 1.22e-11
L15 N14 Port2 3.02e-10
R15 N14 Port2 3.60e+01
.ENDS GR355DD72J154KW01

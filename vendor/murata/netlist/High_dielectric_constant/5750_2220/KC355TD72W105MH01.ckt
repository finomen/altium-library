*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.00e+00[uF]/450[V]
* Murata P/N :KC355TD72W105MH01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355TD72W105MH01 Port1 Port2
C01 Port1 N01 9.24e-07
R01 Port1 N01 1.00e+09
L02 N01 N02 4.97e-11
R03 N02 N03 3.07e-03
C04 N03 N04 1.46e-04
R04 N03 N04 6.30e-03
L05 N04 N05 3.20e-11
R05 N04 N05 1.99e-01
L06 N05 N06 2.45e-10
R06 N05 N06 5.74e-02
L07 N06 N07 2.99e-10
R07 N06 N07 1.45e-02
L08 N07 N08 1.86e-09
R08 N07 N08 6.09e-03
C09 N08 N09 1.95e-06
L09 N08 N09 1.89e-10
R09 N08 N09 8.99e-02
C10 N09 N10 1.45e-06
L10 N09 N10 7.47e-11
R10 N09 N10 4.95e-02
C11 N10 N11 3.67e-06
L11 N10 N11 1.75e-11
R11 N10 N11 1.71e-02
C12 N11 N12 1.20e-06
L12 N11 N12 2.84e-11
R12 N11 N12 2.10e-02
C13 N12 Port2 3.24e-12
L13 N12 Port2 1.03e-09
R13 N12 Port2 3.89e+02
.ENDS KC355TD72W105MH01

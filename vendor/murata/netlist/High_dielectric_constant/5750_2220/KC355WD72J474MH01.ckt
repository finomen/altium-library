*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :KC355WD72J474MH01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355WD72J474MH01 Port1 Port2
C01 Port1 N01 4.37e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 7.36e-12
R03 N02 N03 7.90e-03
C04 N03 N04 1.36e-04
R04 N03 N04 1.75e-02
L05 N04 N05 1.34e-11
R05 N04 N05 8.38e-02
L06 N05 N06 2.91e-10
R06 N05 N06 7.34e-02
L07 N06 N07 4.52e-10
R07 N06 N07 8.54e-03
C08 N07 N08 8.21e-07
L08 N07 N08 2.51e-10
R08 N07 N08 1.38e-01
C09 N08 N09 8.65e-07
L09 N08 N09 5.72e-11
R09 N08 N09 6.35e-02
C10 N09 N10 1.33e-06
L10 N09 N10 2.66e-11
R10 N09 N10 2.26e-02
C11 N10 N11 5.46e-07
L11 N10 N11 2.73e-11
R11 N10 N11 3.85e-02
C12 N11 N12 4.83e-12
L12 N11 N12 8.68e-10
R12 N11 N12 1.84e+02
C13 N12 Port2 6.80e-12
L13 N12 Port2 4.28e-10
R13 N12 Port2 4.23e+01
.ENDS KC355WD72J474MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/6.80e-01[uF]/450[V]
* Murata P/N :GR355DD7LP684KW01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355DD7LP684KW01 Port1 Port2
C01 Port1 N01 6.84e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 1.91e-10
R03 N02 N03 4.04e-03
C04 N03 N04 2.05e-04
R04 N03 N04 2.22e+01
C05 N04 N05 3.25e-04
R05 N04 N05 1.80e+00
C06 N05 N06 3.20e-04
R06 N05 N06 3.41e-01
C07 N06 N07 2.63e-04
R07 N06 N07 7.23e-02
C08 N07 N08 1.76e-04
R08 N07 N08 1.60e-02
C09 N08 N09 2.05e-04
R09 N08 N09 2.97e-03
L10 N09 N10 5.80e-11
R10 N09 N10 3.04e-02
L11 N10 N11 5.35e-11
R11 N10 N11 1.79e-02
L12 N11 N12 5.49e-11
R12 N11 N12 1.66e-02
C13 N12 N13 1.23e-06
L13 N12 N13 9.49e-11
R13 N12 N13 4.91e-02
C14 N13 N14 5.01e-07
L14 N13 N14 8.09e-11
R14 N13 N14 4.19e-02
C15 N14 Port2 1.07e-11
L15 N14 Port2 2.93e-10
R15 N14 Port2 4.23e+01
.ENDS GR355DD7LP684KW01

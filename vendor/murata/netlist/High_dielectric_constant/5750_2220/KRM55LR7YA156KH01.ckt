*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e+01[uF]/35[V]
* Murata P/N :KRM55LR7YA156KH01
* Property : C = 1.50e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR7YA156KH01 Port1 Port2
C01 Port1 N01 1.47e-05
R01 Port1 N01 6.67e+06
L02 N01 N02 8.98e-12
R03 N02 N03 4.87e-03
C04 N03 N04 1.85e-03
R04 N03 N04 4.13e-01
C05 N04 N05 1.42e-03
R05 N04 N05 4.92e-02
C06 N05 N06 2.11e-03
R06 N05 N06 2.80e-03
L07 N06 N07 7.78e-11
R07 N06 N07 5.88e-02
L08 N07 N08 5.61e-12
R08 N07 N08 4.50e-02
L09 N08 N09 5.11e-10
R09 N08 N09 2.60e-02
L10 N09 N10 8.38e-10
R10 N09 N10 4.10e-03
C11 N10 N11 4.90e-05
L11 N10 N11 6.76e-11
R11 N10 N11 3.03e-03
C12 N11 N12 7.54e-06
L12 N11 N12 1.57e-10
R12 N11 N12 6.19e-03
C13 N12 N13 2.91e-12
L13 N12 N13 1.22e-09
R13 N12 N13 4.39e+02
C14 N13 Port2 2.76e-11
L14 N13 Port2 7.72e-11
R14 N13 Port2 4.75e+00
.ENDS KRM55LR7YA156KH01

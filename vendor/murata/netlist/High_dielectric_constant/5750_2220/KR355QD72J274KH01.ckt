*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.70e-01[uF]/630[V]
* Murata P/N :KR355QD72J274KH01
* Property : C = 2.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355QD72J274KH01 Port1 Port2
C01 Port1 N01 2.57e-07
R01 Port1 N01 3.70e+08
L02 N01 N02 3.39e-12
R03 N02 N03 1.75e-03
C04 N03 N04 3.47e-05
R04 N03 N04 2.32e-02
L05 N04 N05 1.48e-11
R05 N04 N05 9.24e-02
L06 N05 N06 3.39e-10
R06 N05 N06 8.10e-02
L07 N06 N07 3.08e-09
R07 N06 N07 1.13e-02
L08 N07 N08 5.12e-11
R08 N07 N08 2.02e-03
C09 N08 N09 7.90e-07
L09 N08 N09 7.84e-11
R09 N08 N09 7.48e-02
C10 N09 N10 5.10e-07
L10 N09 N10 4.36e-11
R10 N09 N10 6.58e-02
C11 N10 N11 3.31e-12
L11 N10 N11 1.13e-09
R11 N10 N11 4.28e+02
C12 N11 Port2 2.02e-11
L12 N11 Port2 1.00e-10
R12 N11 Port2 9.64e+00
.ENDS KR355QD72J274KH01

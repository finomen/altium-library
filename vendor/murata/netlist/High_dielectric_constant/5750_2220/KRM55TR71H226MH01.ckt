*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e+01[uF]/50[V]
* Murata P/N :KRM55TR71H226MH01
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR71H226MH01 Port1 Port2
C01 Port1 N01 1.93e-05
R01 Port1 N01 4.55e+06
L02 N01 N02 1.09e-11
R03 N02 N03 2.82e-03
C04 N03 N04 2.66e-03
R04 N03 N04 3.18e-01
C05 N04 N05 1.81e-03
R05 N04 N05 4.01e-02
C06 N05 N06 2.85e-03
R06 N05 N06 2.07e-03
L07 N06 N07 9.05e-11
R07 N06 N07 4.48e-02
L08 N07 N08 6.60e-10
R08 N07 N08 2.15e-02
L09 N08 N09 1.29e-09
R09 N08 N09 3.54e-03
C10 N09 N10 4.03e-05
L10 N09 N10 2.24e-10
R10 N09 N10 8.49e-03
C11 N10 N11 2.00e-05
L11 N10 N11 1.13e-10
R11 N10 N11 4.91e-03
C12 N11 Port2 2.59e-12
L12 N11 Port2 1.25e-09
R12 N11 Port2 5.78e+02
.ENDS KRM55TR71H226MH01

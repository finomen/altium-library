*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e+01[uF]/50[V]
* Murata P/N :KRM55QR71H226KH13
* Property : C = 2.20e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QR71H226KH13 Port1 Port2
C01 Port1 N01 2.09e-05
R01 Port1 N01 4.55e+06
L02 N01 N02 4.02e-11
R03 N02 N03 2.88e-03
C04 N03 N04 3.19e-03
R04 N03 N04 2.76e-03
L05 N04 N05 8.81e-11
R05 N04 N05 2.75e-02
L06 N05 N06 7.50e-10
R06 N05 N06 2.00e-02
L07 N06 N07 1.36e-09
R07 N06 N07 3.02e-03
C08 N07 N08 5.67e-05
L08 N07 N08 1.19e-10
R08 N07 N08 5.08e-03
C09 N08 N09 2.71e-05
L09 N08 N09 8.99e-11
R09 N08 N09 5.71e-03
C10 N09 Port2 2.99e-12
L10 N09 Port2 1.25e-09
R10 N09 Port2 2.76e+02
.ENDS KRM55QR71H226KH13

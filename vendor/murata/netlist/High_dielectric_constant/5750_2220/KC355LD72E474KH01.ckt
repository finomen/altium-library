*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/4.70e-01[uF]/250[V]
* Murata P/N :KC355LD72E474KH01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355LD72E474KH01 Port1 Port2
C01 Port1 N01 4.34e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 3.13e-12
R03 N02 N03 9.14e-03
C04 N03 N04 1.51e-04
R04 N03 N04 1.54e-02
L05 N04 N05 2.41e-10
R05 N04 N05 8.39e-02
L06 N05 N06 3.27e-10
R06 N05 N06 8.79e-03
C07 N06 N07 1.27e-06
L07 N06 N07 6.79e-11
R07 N06 N07 5.38e-02
C08 N07 N08 4.32e-07
L08 N07 N08 7.06e-11
R08 N07 N08 4.32e-02
C09 N08 N09 4.69e-12
L09 N08 N09 7.63e-10
R09 N08 N09 3.38e+02
C10 N09 Port2 6.53e-12
L10 N09 Port2 4.34e-10
R10 N09 Port2 5.38e+01
.ENDS KC355LD72E474KH01

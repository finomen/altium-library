*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.20e+00[uF]/450[V]
* Murata P/N :KR355WD72W125MH01
* Property : C = 1.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355WD72W125MH01 Port1 Port2
C01 Port1 N01 1.10e-06
R01 Port1 N01 8.33e+07
L02 N01 N02 3.50e-11
R03 N02 N03 6.76e-03
C04 N03 N04 5.74e-04
R04 N03 N04 3.48e-03
L05 N04 N05 4.11e-11
R05 N04 N05 2.56e-01
L06 N05 N06 3.20e-10
R06 N05 N06 6.06e-02
L07 N06 N07 5.49e-10
R07 N06 N07 8.54e-03
C08 N07 N08 2.11e-06
L08 N07 N08 2.66e-10
R08 N07 N08 8.68e-02
C09 N08 N09 2.04e-06
L09 N08 N09 7.88e-11
R09 N08 N09 4.82e-02
C10 N09 N10 2.44e-06
L10 N09 N10 4.27e-11
R10 N09 N10 2.32e-02
C11 N10 N11 1.04e-06
L11 N10 N11 4.57e-11
R11 N10 N11 2.16e-02
C12 N11 N12 3.89e-12
L12 N11 N12 1.01e-09
R12 N11 N12 2.93e+02
C13 N12 Port2 1.62e-11
L13 N12 Port2 1.78e-10
R13 N12 Port2 2.55e+01
.ENDS KR355WD72W125MH01

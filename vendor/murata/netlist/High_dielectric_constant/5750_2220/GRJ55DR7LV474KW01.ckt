*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :GRJ55DR7LV474KW01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRJ55DR7LV474KW01 Port1 Port2
C01 Port1 N01 4.83e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 2.82e-10
R03 N02 N03 9.04e-03
C04 N03 N04 5.31e-05
R04 N03 N04 3.90e+01
C05 N04 N05 5.51e-05
R05 N04 N05 9.68e+00
C06 N05 N06 4.86e-05
R06 N05 N06 2.03e+00
C07 N06 N07 4.38e-05
R07 N06 N07 4.30e-01
C08 N07 N08 6.62e-05
R08 N07 N08 5.01e-02
C09 N08 N09 3.53e-05
R09 N08 N09 1.98e-02
L10 N09 N10 3.91e-11
R10 N09 N10 1.61e-01
L11 N10 N11 1.19e-10
R11 N10 N11 5.72e-02
C12 N11 N12 1.01e-06
L12 N11 N12 6.42e-11
R12 N11 N12 3.36e-02
C13 N12 N13 2.17e-07
L13 N12 N13 9.28e-11
R13 N12 N13 3.66e-02
C14 N13 Port2 1.20e-11
L14 N13 Port2 2.17e-10
R14 N13 Port2 3.67e+01
.ENDS GRJ55DR7LV474KW01

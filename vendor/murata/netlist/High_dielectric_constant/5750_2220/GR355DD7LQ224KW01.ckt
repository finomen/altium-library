*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/2.20e-01[uF]/630[V]
* Murata P/N :GR355DD7LQ224KW01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355DD7LQ224KW01 Port1 Port2
C01 Port1 N01 2.25e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.75e-10
R03 N02 N03 7.96e-03
C04 N03 N04 7.57e-05
R04 N03 N04 5.24e+01
C05 N04 N05 1.22e-04
R05 N04 N05 4.57e+00
C06 N05 N06 1.17e-04
R06 N05 N06 9.84e-01
C07 N06 N07 1.06e-04
R07 N06 N07 2.15e-01
C08 N07 N08 1.10e-04
R08 N07 N08 4.47e-02
C09 N08 N09 7.96e-05
R09 N08 N09 9.90e-03
L10 N09 N10 2.42e-11
R10 N09 N10 3.58e-02
L11 N10 N11 6.63e-11
R11 N10 N11 3.05e-02
L12 N11 N12 1.49e-11
R12 N11 N12 6.42e-03
C13 N12 N13 4.73e-07
L13 N12 N13 5.52e-11
R13 N12 N13 4.15e-02
C14 N13 N14 1.49e-07
L14 N13 N14 5.14e-11
R14 N13 N14 3.63e-02
C15 N14 Port2 1.11e-11
L15 N14 Port2 4.05e-10
R15 N14 Port2 4.75e+01
.ENDS GR355DD7LQ224KW01

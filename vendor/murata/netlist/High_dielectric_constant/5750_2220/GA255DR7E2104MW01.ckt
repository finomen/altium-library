*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e-01[uF]/250[Vac]
* Murata P/N :GA255DR7E2104MW01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA255DR7E2104MW01 Port1 Port2
C01 Port1 N01 9.79e-08
R01 Port1 N01 2.00e+09
L02 N01 N02 4.50e-12
R03 N02 N03 1.25e-02
C04 N03 N04 7.35e-06
R04 N03 N04 2.16e-01
C05 N04 N05 8.02e-06
R05 N04 N05 1.45e-02
C06 N05 N06 2.69e-05
R06 N05 N06 1.04e-02
C07 N06 N07 5.22e-06
R07 N06 N07 3.99e-03
L08 N07 N08 1.32e-10
R08 N07 N08 1.23e-01
C09 N08 N09 1.86e-07
L09 N08 N09 7.59e-11
R09 N08 N09 7.87e-02
C10 N09 N10 5.65e-08
L10 N09 N10 7.83e-11
R10 N09 N10 7.54e-02
C11 N10 N11 1.13e-11
L11 N10 N11 2.63e-10
R11 N10 N11 2.21e+01
C12 N11 Port2 6.45e-12
L12 N11 Port2 2.47e-10
R12 N11 Port2 3.84e+01
.ENDS GA255DR7E2104MW01

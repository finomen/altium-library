*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/3.30e-01[uF]/630[V]
* Murata P/N :KRM55TR72J334MH01
* Property : C = 3.30e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR72J334MH01 Port1 Port2
C01 Port1 N01 2.89e-07
R01 Port1 N01 3.03e+08
L02 N01 N02 4.72e-12
R03 N02 N03 1.48e-02
C04 N03 N04 2.60e-05
R04 N03 N04 4.90e-02
L05 N04 N05 1.65e-11
R05 N04 N05 3.84e-01
L06 N05 N06 1.60e-10
R06 N05 N06 7.98e-02
L07 N06 N07 6.95e-11
R07 N06 N07 3.78e-03
C08 N07 N08 6.79e-07
L08 N07 N08 1.70e-10
R08 N07 N08 9.62e-02
C09 N08 N09 2.46e-07
L09 N08 N09 8.10e-11
R09 N08 N09 5.03e-02
C10 N09 N10 1.73e-07
L10 N09 N10 3.33e-11
R10 N09 N10 2.72e-02
C11 N10 N11 5.07e-12
L11 N10 N11 8.22e-10
R11 N10 N11 1.27e+02
C12 N11 Port2 6.28e-12
L12 N11 Port2 4.85e-10
R12 N11 Port2 4.28e+01
.ENDS KRM55TR72J334MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :GR355DD7LQ474KW01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR355DD7LQ474KW01 Port1 Port2
C01 Port1 N01 4.70e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 2.10e-10
R03 N02 N03 4.49e-03
C04 N03 N04 1.65e-04
R04 N03 N04 2.68e+01
C05 N04 N05 2.43e-04
R05 N04 N05 2.80e+00
C06 N05 N06 2.43e-04
R06 N05 N06 5.81e-01
C07 N06 N07 2.21e-04
R07 N06 N07 1.35e-01
C08 N07 N08 2.40e-04
R08 N07 N08 2.62e-02
C09 N08 N09 1.73e-04
R09 N08 N09 6.07e-03
L10 N09 N10 4.78e-11
R10 N09 N10 3.18e-02
L11 N10 N11 6.52e-11
R11 N10 N11 2.58e-02
L12 N11 N12 8.08e-11
R12 N11 N12 2.35e-02
C13 N12 N13 6.85e-07
L13 N12 N13 1.23e-10
R13 N12 N13 7.97e-02
C14 N13 N14 4.32e-07
L14 N13 N14 6.94e-11
R14 N13 N14 5.84e-02
C15 N14 N15 7.37e-10
L15 N14 N15 8.46e-12
R15 N14 N15 1.49e-01
C16 N15 Port2 1.43e-11
L16 N15 Port2 1.70e-10
R16 N15 Port2 2.38e+01
.ENDS GR355DD7LQ474KW01

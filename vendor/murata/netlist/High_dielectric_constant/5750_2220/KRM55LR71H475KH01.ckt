*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e+00[uF]/50[V]
* Murata P/N :KRM55LR71H475KH01
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR71H475KH01 Port1 Port2
C01 Port1 N01 4.66e-06
R01 Port1 N01 2.13e+07
L02 N01 N02 2.29e-10
R03 N02 N03 6.81e-03
C04 N03 N04 7.08e-04
R04 N03 N04 6.03e-01
C05 N04 N05 5.86e-04
R05 N04 N05 9.47e-02
C06 N05 N06 5.81e-04
R06 N05 N06 1.07e-02
L07 N06 N07 7.10e-11
R07 N06 N07 8.52e-02
L08 N07 N08 3.35e-10
R08 N07 N08 3.57e-02
L09 N08 N09 5.20e-10
R09 N08 N09 5.16e-03
C10 N09 N10 9.42e-06
L10 N09 N10 9.13e-11
R10 N09 N10 7.27e-03
C11 N10 N11 2.77e-06
L11 N10 N11 1.01e-10
R11 N10 N11 1.00e-02
C12 N11 Port2 3.52e-12
L12 N11 Port2 9.80e-10
R12 N11 Port2 4.43e+02
.ENDS KRM55LR71H475KH01

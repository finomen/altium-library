*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e+01[uF]/25[V]
* Murata P/N :KCM55LR71E156KH01
* Property : C = 1.50e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55LR71E156KH01 Port1 Port2
C01 Port1 N01 1.44e-05
R01 Port1 N01 6.67e+06
L02 N01 N02 2.13e-12
R03 N02 N03 4.92e-03
C04 N03 N04 1.70e-03
R04 N03 N04 7.12e-01
C05 N04 N05 1.81e-03
R05 N04 N05 8.35e-02
C06 N05 N06 1.54e-03
R06 N05 N06 9.80e-03
L07 N06 N07 7.74e-11
R07 N06 N07 8.28e-02
L08 N07 N08 4.16e-10
R08 N07 N08 2.56e-02
L09 N08 N09 8.06e-10
R09 N08 N09 4.58e-03
C10 N09 N10 4.88e-05
L10 N09 N10 7.05e-11
R10 N09 N10 3.54e-03
C11 N10 N11 6.87e-06
L11 N10 N11 1.68e-10
R11 N10 N11 8.53e-03
C12 N11 Port2 3.00e-12
L12 N11 Port2 1.19e-09
R12 N11 Port2 5.68e+02
.ENDS KCM55LR71E156KH01

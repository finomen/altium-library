*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/4.70e-01[uF]/630[V]
* Murata P/N :KR355LD7LQ474KV01
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355LD7LQ474KV01 Port1 Port2
C01 Port1 N01 4.47e-07
R01 Port1 N01 2.13e+08
L02 N01 N02 1.66e-11
R03 N02 N03 2.02e-03
C04 N03 N04 5.36e-05
R04 N03 N04 1.47e-02
L05 N04 N05 4.30e-11
R05 N04 N05 2.68e-01
L06 N05 N06 2.87e-10
R06 N05 N06 7.75e-02
L07 N06 N07 3.04e-09
R07 N06 N07 9.59e-03
L08 N07 N08 1.48e-10
R08 N07 N08 3.07e-03
C09 N08 N09 1.32e-06
L09 N08 N09 7.37e-11
R09 N08 N09 5.49e-02
C10 N09 N10 4.83e-07
L10 N09 N10 6.98e-11
R10 N09 N10 4.80e-02
C11 N10 Port2 3.32e-12
L11 N10 Port2 1.09e-09
R11 N10 Port2 6.30e+02
.ENDS KR355LD7LQ474KV01

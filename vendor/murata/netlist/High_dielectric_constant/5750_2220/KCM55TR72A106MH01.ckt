*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+01[uF]/100[V]
* Murata P/N :KCM55TR72A106MH01
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55TR72A106MH01 Port1 Port2
C01 Port1 N01 9.12e-06
R01 Port1 N01 1.00e+07
L02 N01 N02 7.03e-11
R03 N02 N03 3.83e-03
C04 N03 N04 8.90e-04
R04 N03 N04 1.24e+00
C05 N04 N05 9.56e-04
R05 N04 N05 1.02e-01
C06 N05 N06 9.00e-04
R06 N05 N06 1.00e-02
L07 N06 N07 8.52e-11
R07 N06 N07 8.19e-02
L08 N07 N08 6.51e-10
R08 N07 N08 2.94e-02
L09 N08 N09 1.42e-09
R09 N08 N09 2.97e-03
C10 N09 N10 2.01e-05
L10 N09 N10 1.96e-10
R10 N09 N10 1.26e-02
C11 N10 N11 1.31e-05
L11 N10 N11 8.15e-11
R11 N10 N11 7.06e-03
C12 N11 Port2 2.63e-12
L12 N11 Port2 1.14e-09
R12 N11 Port2 4.62e+02
.ENDS KCM55TR72A106MH01

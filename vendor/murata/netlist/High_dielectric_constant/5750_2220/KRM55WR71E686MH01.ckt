*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e+01[uF]/25[V]
* Murata P/N :KRM55WR71E686MH01
* Property : C = 6.80e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55WR71E686MH01 Port1 Port2
C01 Port1 N01 6.35e-05
R01 Port1 N01 1.47e+06
L02 N01 N02 8.10e-12
R03 N02 N03 2.85e-03
C04 N03 N04 8.78e-03
R04 N03 N04 1.26e-01
C05 N04 N05 4.25e-03
R05 N04 N05 2.21e-02
L06 N05 N06 1.38e-10
R06 N05 N06 3.51e-02
L07 N06 N07 1.07e-09
R07 N06 N07 1.32e-02
L08 N07 N08 1.24e-09
R08 N07 N08 3.43e-03
C09 N08 N09 2.15e-04
L09 N08 N09 1.94e-10
R09 N08 N09 5.02e-03
C10 N09 N10 2.83e-04
L10 N09 N10 4.24e-11
R10 N09 N10 2.20e-03
C11 N10 N11 3.65e-08
L11 N10 N11 1.46e-11
R11 N10 N11 1.67e-02
C12 N11 Port2 2.60e-12
L12 N11 Port2 1.26e-09
R12 N11 Port2 6.25e+02
.ENDS KRM55WR71E686MH01

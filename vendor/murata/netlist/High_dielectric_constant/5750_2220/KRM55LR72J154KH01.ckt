*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e-01[uF]/630[V]
* Murata P/N :KRM55LR72J154KH01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72J154KH01 Port1 Port2
C01 Port1 N01 1.45e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 1.15e-12
R03 N02 N03 5.74e-03
C04 N03 N04 1.31e-05
R04 N03 N04 8.85e-02
C05 N04 N05 3.50e-06
R05 N04 N05 2.06e-02
L06 N05 N06 7.42e-12
R06 N05 N06 3.01e-01
L07 N06 N07 1.69e-10
R07 N06 N07 9.94e-02
L08 N07 N08 1.06e-09
R08 N07 N08 2.02e-02
C09 N08 N09 4.03e-07
L09 N08 N09 4.92e-11
R09 N08 N09 3.55e-02
C10 N09 N10 1.37e-07
L10 N09 N10 4.49e-11
R10 N09 N10 4.31e-02
C11 N10 N11 4.69e-12
L11 N10 N11 9.75e-10
R11 N10 N11 1.74e+02
C12 N11 Port2 7.18e-12
L12 N11 Port2 4.61e-10
R12 N11 Port2 3.41e+01
.ENDS KRM55LR72J154KH01

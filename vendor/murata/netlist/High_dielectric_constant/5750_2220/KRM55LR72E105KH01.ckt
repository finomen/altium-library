*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+00[uF]/250[V]
* Murata P/N :KRM55LR72E105KH01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55LR72E105KH01 Port1 Port2
C01 Port1 N01 9.93e-07
R01 Port1 N01 1.00e+08
L02 N01 N02 1.15e-11
R03 N02 N03 5.67e-03
C04 N03 N04 1.46e-04
R04 N03 N04 2.34e+00
C05 N04 N05 1.32e-04
R05 N04 N05 3.71e-01
C06 N05 N06 1.16e-04
R06 N05 N06 4.51e-02
C07 N06 N07 4.65e-05
R07 N06 N07 9.86e-03
L08 N07 N08 4.05e-11
R08 N07 N08 2.06e-01
L09 N08 N09 2.91e-10
R09 N08 N09 6.54e-02
L10 N09 N10 1.51e-09
R10 N09 N10 9.78e-03
C11 N10 N11 1.95e-06
L11 N10 N11 9.66e-11
R11 N10 N11 1.77e-02
C12 N11 N12 8.67e-07
L12 N11 N12 7.50e-11
R12 N11 N12 2.32e-02
C13 N12 Port2 3.06e-12
L13 N12 Port2 1.20e-09
R13 N12 Port2 5.92e+02
.ENDS KRM55LR72E105KH01

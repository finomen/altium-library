*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/1.50e+00[uF]/250[V]
* Murata P/N :KR355TD72E155MH01
* Property : C = 1.50e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355TD72E155MH01 Port1 Port2
C01 Port1 N01 1.36e-06
R01 Port1 N01 6.67e+07
L02 N01 N02 2.05e-11
R03 N02 N03 2.60e-03
C04 N03 N04 1.07e-04
R04 N03 N04 5.58e-03
L05 N04 N05 3.78e-11
R05 N04 N05 2.78e-01
L06 N05 N06 2.73e-10
R06 N05 N06 6.22e-02
L07 N06 N07 1.72e-09
R07 N06 N07 8.79e-03
C08 N07 N08 2.42e-06
L08 N07 N08 2.42e-10
R08 N07 N08 6.93e-02
C09 N08 N09 1.98e-06
L09 N08 N09 8.34e-11
R09 N08 N09 4.28e-02
C10 N09 N10 2.79e-06
L10 N09 N10 3.91e-11
R10 N09 N10 1.65e-02
C11 N10 N11 7.29e-07
L11 N10 N11 6.32e-11
R11 N10 N11 2.07e-02
C12 N11 N12 3.68e-12
L12 N11 N12 1.01e-09
R12 N11 N12 3.39e+02
C13 N12 Port2 1.52e-11
L13 N12 Port2 1.29e-10
R13 N12 Port2 1.17e+01
.ENDS KR355TD72E155MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7S(-55to125[deg])/4.70e+01[uF]/25[V]
* Murata P/N :KRM55QC71E476KH13
* Property : C = 4.70e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55QC71E476KH13 Port1 Port2
C01 Port1 N01 4.46e-05
R01 Port1 N01 2.13e+06
L02 N01 N02 1.02e-11
R03 N02 N03 2.45e-03
C04 N03 N04 6.64e-03
R04 N03 N04 2.22e-01
C05 N04 N05 4.55e-03
R05 N04 N05 3.73e-02
C06 N05 N06 6.33e-03
R06 N05 N06 3.64e-03
L07 N06 N07 8.98e-11
R07 N06 N07 2.91e-02
L08 N07 N08 8.10e-10
R08 N07 N08 1.70e-02
L09 N08 N09 1.22e-09
R09 N08 N09 3.19e-03
C10 N09 N10 1.61e-04
L10 N09 N10 1.10e-10
R10 N09 N10 3.53e-03
C11 N10 N11 4.73e-05
L11 N10 N11 1.52e-10
R11 N10 N11 5.25e-03
C12 N11 Port2 2.50e-12
L12 N11 Port2 1.19e-09
R12 N11 Port2 3.38e+02
.ENDS KRM55QC71E476KH13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/6.80e-01[uF]/450[V]
* Murata P/N :KRM55TR72W684MH01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR72W684MH01 Port1 Port2
C01 Port1 N01 6.52e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 1.20e-11
R03 N02 N03 1.29e-02
C04 N03 N04 7.32e-05
R04 N03 N04 1.99e-02
L05 N04 N05 1.55e-11
R05 N04 N05 1.39e-01
L06 N05 N06 2.31e-10
R06 N05 N06 6.89e-02
L07 N06 N07 1.96e-10
R07 N06 N07 3.50e-03
C08 N07 N08 1.63e-06
L08 N07 N08 1.60e-10
R08 N07 N08 3.32e-02
C09 N08 N09 4.91e-07
L09 N08 N09 7.48e-11
R09 N08 N09 1.97e-02
C10 N09 N10 5.02e-12
L10 N09 N10 8.36e-10
R10 N09 N10 8.63e+01
C11 N10 Port2 6.78e-12
L11 N10 Port2 4.75e-10
R11 N10 Port2 4.34e+01
.ENDS KRM55TR72W684MH01

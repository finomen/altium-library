*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.00e+00[uF]/630[V]
* Murata P/N :KRM55TR7LV105MH01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR7LV105MH01 Port1 Port2
C01 Port1 N01 9.40e-07
R01 Port1 N01 1.00e+08
L02 N01 N02 2.72e-11
R03 N02 N03 1.09e-02
C04 N03 N04 1.40e-04
R04 N03 N04 6.36e-01
C05 N04 N05 1.11e-04
R05 N04 N05 9.18e-02
C06 N05 N06 1.37e-04
R06 N05 N06 8.28e-03
L07 N06 N07 4.70e-11
R07 N06 N07 2.10e-01
L08 N07 N08 2.98e-10
R08 N07 N08 6.44e-02
L09 N08 N09 2.19e-10
R09 N08 N09 5.89e-03
C10 N09 N10 2.07e-06
L10 N09 N10 1.73e-10
R10 N09 N10 3.98e-02
C11 N10 N11 7.96e-07
L11 N10 N11 9.06e-11
R11 N10 N11 2.10e-02
C12 N11 Port2 3.14e-12
L12 N11 Port2 1.18e-09
R12 N11 Port2 2.44e+02
.ENDS KRM55TR7LV105MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/1.50e-01[uF]/1000[V]
* Murata P/N :KRM55TR73A154MH01
* Property : C = 1.50e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR73A154MH01 Port1 Port2
C01 Port1 N01 1.35e-07
R01 Port1 N01 6.67e+08
L02 N01 N02 1.27e-12
R03 N02 N03 1.39e-02
C04 N03 N04 1.30e-05
R04 N03 N04 1.00e-01
C05 N04 N05 9.89e-06
R05 N04 N05 1.13e-02
C06 N05 N06 3.76e-05
R06 N05 N06 8.41e-03
L07 N06 N07 9.33e-12
R07 N06 N07 9.49e-02
L08 N07 N08 1.45e-10
R08 N07 N08 5.05e-02
L09 N08 N09 7.89e-10
R09 N08 N09 1.22e-02
C10 N09 N10 3.53e-07
L10 N09 N10 1.52e-10
R10 N09 N10 9.88e-02
C11 N10 N11 1.51e-07
L11 N10 N11 4.67e-11
R11 N10 N11 5.18e-02
C12 N11 N12 5.17e-12
L12 N11 N12 8.75e-10
R12 N11 N12 8.35e+01
C13 N12 Port2 6.13e-12
L13 N12 Port2 5.21e-10
R13 N12 Port2 4.70e+01
.ENDS KRM55TR73A154MH01

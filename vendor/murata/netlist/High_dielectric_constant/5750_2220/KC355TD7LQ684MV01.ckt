*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/6.80e-01[uF]/630[V]
* Murata P/N :KC355TD7LQ684MV01
* Property : C = 6.80e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KC355TD7LQ684MV01 Port1 Port2
C01 Port1 N01 6.49e-07
R01 Port1 N01 1.47e+08
L02 N01 N02 1.13e-11
R03 N02 N03 8.14e-03
C04 N03 N04 1.96e-04
R04 N03 N04 6.35e-03
L05 N04 N05 2.39e-11
R05 N04 N05 1.93e-01
L06 N05 N06 1.94e-10
R06 N05 N06 7.47e-02
L07 N06 N07 6.57e-10
R07 N06 N07 1.05e-02
C08 N07 N08 1.41e-06
L08 N07 N08 1.88e-10
R08 N07 N08 8.37e-02
C09 N08 N09 5.34e-07
L09 N08 N09 1.04e-10
R09 N08 N09 4.60e-02
C10 N09 N10 3.45e-07
L10 N09 N10 4.89e-11
R10 N09 N10 2.69e-02
C11 N10 N11 4.87e-12
L11 N10 N11 8.17e-10
R11 N10 N11 1.36e+02
C12 N11 Port2 7.38e-12
L12 N11 Port2 4.08e-10
R12 N11 Port2 7.05e+01
.ENDS KC355TD7LQ684MV01

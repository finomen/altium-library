*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7T(-55to125[deg])/5.60e-01[uF]/630[V]
* Murata P/N :KR355QD7LQ564KV01
* Property : C = 5.60e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KR355QD7LQ564KV01 Port1 Port2
C01 Port1 N01 5.42e-07
R01 Port1 N01 1.79e+08
L02 N01 N02 5.13e-12
R03 N02 N03 8.38e-03
C04 N03 N04 2.10e-04
R04 N03 N04 7.73e-03
L05 N04 N05 3.05e-10
R05 N04 N05 6.36e-02
L06 N05 N06 1.35e-12
R06 N05 N06 1.49e-02
L07 N06 N07 3.49e-10
R07 N06 N07 6.99e-03
C08 N07 N08 1.53e-06
L08 N07 N08 8.97e-11
R08 N07 N08 5.36e-02
C09 N08 N09 6.88e-07
L09 N08 N09 7.02e-11
R09 N08 N09 4.57e-02
C10 N09 N10 4.37e-12
L10 N09 N10 9.12e-10
R10 N09 N10 1.64e+02
C11 N10 Port2 1.11e-11
L11 N10 Port2 2.88e-10
R11 N10 Port2 4.31e+01
.ENDS KR355QD7LQ564KV01

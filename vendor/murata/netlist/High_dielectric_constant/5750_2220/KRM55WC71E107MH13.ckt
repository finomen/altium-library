*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7S(-55to125[deg])/1.00e+02[uF]/25[V]
* Murata P/N :KRM55WC71E107MH13
* Property : C = 1.00e+02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55WC71E107MH13 Port1 Port2
C01 Port1 N01 8.86e-05
R01 Port1 N01 1.00e+06
L02 N01 N02 5.31e-12
R03 N02 N03 3.02e-03
C04 N03 N04 9.33e-03
R04 N03 N04 6.75e-02
C05 N04 N05 6.92e-03
R05 N04 N05 9.99e-03
L06 N05 N06 1.48e-10
R06 N05 N06 2.75e-02
L07 N06 N07 9.53e-10
R07 N06 N07 1.35e-02
L08 N07 N08 1.77e-09
R08 N07 N08 4.36e-03
C09 N08 N09 2.94e-04
L09 N08 N09 2.14e-10
R09 N08 N09 3.85e-03
C10 N09 N10 2.74e-04
L10 N09 N10 7.60e-11
R10 N09 N10 2.48e-03
C11 N10 Port2 2.68e-12
L11 N10 Port2 1.18e-09
R11 N10 Port2 3.13e+02
.ENDS KRM55WC71E107MH13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-01[uF]/1250[V]
* Murata P/N :KRM55TR7LX224MH01
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55TR7LX224MH01 Port1 Port2
C01 Port1 N01 1.95e-07
R01 Port1 N01 4.55e+08
L02 N01 N02 2.14e-11
R03 N02 N03 1.78e-02
C04 N03 N04 1.58e-05
R04 N03 N04 8.74e-02
C05 N04 N05 9.11e-05
R05 N04 N05 2.07e-03
L06 N05 N06 2.00e-10
R06 N05 N06 1.46e-01
L07 N06 N07 1.46e-11
R07 N06 N07 1.13e-01
L08 N07 N08 5.28e-11
R08 N07 N08 2.65e-03
C09 N08 N09 4.46e-07
L09 N08 N09 1.60e-10
R09 N08 N09 1.19e-01
C10 N09 N10 1.66e-07
L10 N09 N10 8.33e-11
R10 N09 N10 6.29e-02
C11 N10 N11 9.00e-08
L11 N10 N11 4.50e-11
R11 N10 N11 4.14e-02
C12 N11 Port2 3.22e-12
L12 N11 Port2 1.13e-09
R12 N11 Port2 2.50e+02
.ENDS KRM55TR7LX224MH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-03[uF]/250[Vac]
* Murata P/N :GA242QR7E2102MW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA242QR7E2102MW01 Port1 Port2
C01 Port1 N01 1.07e-09
R01 Port1 N01 2.00e+09
L02 N01 N02 2.31e-10
R03 N02 N03 2.79e-01
C04 N03 N04 1.72e-08
R04 N03 N04 1.85e+02
C05 N04 N05 8.21e-08
R05 N04 N05 1.80e+01
C06 N05 N06 6.00e-08
R06 N05 N06 2.48e+00
C07 N06 N07 5.15e-08
R07 N06 N07 3.32e-01
C08 N07 N08 2.53e-08
R08 N07 N08 2.07e-01
C09 N08 N09 6.17e-09
L09 N08 N09 4.42e-11
R09 N08 N09 3.87e-01
C10 N09 N10 1.97e-10
L10 N09 N10 7.54e-11
R10 N09 N10 6.26e-01
C11 N10 Port2 2.20e-12
L11 N10 Port2 6.62e-10
R11 N10 Port2 4.93e+01
.ENDS GA242QR7E2102MW01

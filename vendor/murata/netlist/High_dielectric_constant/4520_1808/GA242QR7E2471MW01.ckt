*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/4.70e-04[uF]/250[Vac]
* Murata P/N :GA242QR7E2471MW01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 500[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA242QR7E2471MW01 Port1 Port2
C01 Port1 N01 4.82e-10
R01 Port1 N01 2.00e+09
L02 N01 N02 6.40e-11
R03 N02 N03 3.76e-01
C04 N03 N04 1.30e-08
R04 N03 N04 2.74e+01
C05 N04 N05 2.24e-08
R05 N04 N05 1.06e+00
C06 N05 N06 4.63e-09
R06 N05 N06 5.43e-01
C07 N06 N07 2.49e-09
L07 N06 N07 4.17e-11
R07 N06 N07 4.93e-01
C08 N07 N08 4.03e-10
L08 N07 N08 4.72e-11
R08 N07 N08 6.26e-01
C09 N08 N09 7.03e-12
L09 N08 N09 2.53e-10
R09 N08 N09 2.18e+01
C10 N09 Port2 1.74e-12
L10 N09 Port2 5.69e-10
R10 N09 Port2 4.09e+01
.ENDS GA242QR7E2471MW01

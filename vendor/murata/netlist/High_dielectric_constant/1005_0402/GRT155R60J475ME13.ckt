*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/4.70e+00[uF]/6.3[V]
* Murata P/N :GRT155R60J475ME13
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R60J475ME13 Port1 Port2
C01 Port1 N01 3.83e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.65e-10
R03 N02 N03 5.60e-03
C04 N03 N04 2.12e-04
R04 N03 N04 2.60e+01
C05 N04 N05 3.05e-04
R05 N04 N05 3.47e+00
C06 N05 N06 2.77e-04
R06 N05 N06 5.91e-01
C07 N06 N07 3.50e-04
R07 N06 N07 7.02e-02
C08 N07 N08 3.17e-04
R08 N07 N08 1.06e-02
C09 N08 N09 3.46e-04
R09 N08 N09 1.79e-03
L10 N09 N10 4.28e-11
R10 N09 N10 4.30e-02
L11 N10 N11 1.90e-10
R11 N10 N11 1.88e-02
C12 N11 N12 6.98e-06
L12 N11 N12 5.46e-11
R12 N11 N12 3.05e-03
C13 N12 N13 1.72e-10
L13 N12 N13 2.36e-11
R13 N12 N13 1.42e-01
C14 N13 Port2 1.14e-11
L14 N13 Port2 2.22e-11
R14 N13 Port2 3.31e+00
.ENDS GRT155R60J475ME13

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7S(-55to125[deg])/1.00e-01[uF]/4[V]
* Murata P/N :LLL153C70G104ME01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153C70G104ME01 Port1 Port2
C01 Port1 N01 8.03e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 5.35e-11
R03 N02 N03 1.46e-02
C04 N03 N04 1.87e-06
R04 N03 N04 7.27e+02
C05 N04 N05 2.23e-06
R05 N04 N05 6.79e+01
C06 N05 N06 2.07e-06
R06 N05 N06 1.00e+01
C07 N06 N07 1.63e-06
R07 N06 N07 1.91e+00
C08 N07 N08 1.43e-06
R08 N07 N08 3.28e-01
C09 N08 N09 1.12e-06
R09 N08 N09 6.71e-02
C10 N09 N10 1.17e-06
R10 N09 N10 1.39e-02
L11 N10 N11 2.40e-11
R11 N10 N11 7.31e-02
C12 N11 N12 1.25e-07
L12 N11 N12 7.85e-12
R12 N11 N12 2.17e-02
C13 N12 N13 3.97e-08
L13 N12 N13 7.89e-12
R13 N12 N13 2.55e-02
C14 N13 Port2 2.82e-11
L14 N13 Port2 8.11e-12
R14 N13 Port2 2.49e+00
.ENDS LLL153C70G104ME01

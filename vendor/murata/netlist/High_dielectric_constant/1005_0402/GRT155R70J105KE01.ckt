*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :GRT155R70J105KE01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R70J105KE01 Port1 Port2
C01 Port1 N01 5.33e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.55e-10
R03 N02 N03 9.60e-03
C04 N03 N04 1.67e-05
R04 N03 N04 5.78e+01
C05 N04 N05 1.57e-05
R05 N04 N05 6.71e+00
C06 N05 N06 1.44e-05
R06 N05 N06 8.59e-01
C07 N06 N07 1.25e-05
R07 N06 N07 1.30e-01
C08 N07 N08 8.37e-06
R08 N07 N08 2.18e-02
L09 N08 N09 2.99e-11
R09 N08 N09 2.19e-01
L10 N09 N10 1.03e-10
R10 N09 N10 4.22e-02
C11 N10 N11 3.08e-06
L11 N10 N11 1.46e-11
R11 N10 N11 4.60e-03
C12 N11 N12 7.48e-07
L12 N11 N12 3.16e-11
R12 N11 N12 1.01e-02
C13 N12 Port2 8.41e-12
L13 N12 Port2 2.03e-11
R13 N12 Port2 2.08e+00
.ENDS GRT155R70J105KE01

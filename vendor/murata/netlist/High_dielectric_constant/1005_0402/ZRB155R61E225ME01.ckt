*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :ZRB155R61E225ME01
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB155R61E225ME01 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.61e-10
R03 N02 N03 6.22e-03
C04 N03 N04 8.51e-05
R04 N03 N04 3.08e+01
C05 N04 N05 7.56e-05
R05 N04 N05 4.59e+00
C06 N05 N06 6.87e-05
R06 N05 N06 6.27e-01
C07 N06 N07 5.81e-05
R07 N06 N07 8.06e-02
C08 N07 N08 4.00e-05
R08 N07 N08 1.35e-02
L09 N08 N09 1.45e-11
R09 N08 N09 9.85e-02
L10 N09 N10 2.13e-11
R10 N09 N10 4.31e-02
L11 N10 N11 1.64e-10
R11 N10 N11 2.75e-02
C12 N11 N12 7.80e-06
L12 N11 N12 2.32e-11
R12 N11 N12 4.86e-03
C13 N12 N13 2.69e-06
L13 N12 N13 3.30e-11
R13 N12 N13 7.71e-03
C14 N13 Port2 1.72e-12
L14 N13 Port2 7.74e-11
R14 N13 Port2 2.85e+01
.ENDS ZRB155R61E225ME01

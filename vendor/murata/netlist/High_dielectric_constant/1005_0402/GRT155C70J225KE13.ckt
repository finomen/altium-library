*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7S(-55to125[deg])/2.20e+00[uF]/6.3[V]
* Murata P/N :GRT155C70J225KE13
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C70J225KE13 Port1 Port2
C01 Port1 N01 1.73e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 1.32e-10
R03 N02 N03 4.94e-03
C04 N03 N04 1.13e-04
R04 N03 N04 2.94e+01
C05 N04 N05 1.08e-04
R05 N04 N05 4.75e+00
C06 N05 N06 8.26e-05
R06 N05 N06 1.07e+00
C07 N06 N07 9.08e-05
R07 N06 N07 1.74e-01
C08 N07 N08 6.20e-05
R08 N07 N08 4.23e-02
C09 N08 N09 4.61e-05
R09 N08 N09 8.20e-03
L10 N09 N10 1.45e-11
R10 N09 N10 8.42e-02
L11 N10 N11 1.40e-10
R11 N10 N11 2.36e-02
L12 N11 N12 2.16e-11
R12 N11 N12 2.29e-02
C13 N12 N13 6.46e-06
L13 N12 N13 3.00e-11
R13 N12 N13 4.18e-03
C14 N13 N14 2.41e-06
L14 N13 N14 4.03e-11
R14 N13 N14 6.96e-03
C15 N14 N15 7.25e-12
L15 N14 N15 3.48e-11
R15 N14 N15 8.36e+02
C16 N15 Port2 1.06e-11
L16 N15 Port2 2.01e-11
R16 N15 Port2 8.65e-01
.ENDS GRT155C70J225KE13

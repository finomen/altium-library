*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7S(-55to125[deg])/1.00e+00[uF]/2.5[V]
* Murata P/N :LLL153C70E105ME21
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153C70E105ME21 Port1 Port2
C01 Port1 N01 8.36e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 5.08e-11
R03 N02 N03 3.65e-03
C04 N03 N04 2.19e-05
R04 N03 N04 2.42e+02
C05 N04 N05 5.75e-05
R05 N04 N05 1.77e+01
C06 N05 N06 3.70e-05
R06 N05 N06 4.74e+00
C07 N06 N07 4.16e-05
R07 N06 N07 6.12e-01
C08 N07 N08 4.34e-05
R08 N07 N08 7.58e-02
C09 N08 N09 4.28e-05
R09 N08 N09 9.80e-03
L10 N09 N10 1.08e-11
R10 N09 N10 5.22e-02
L11 N10 N11 6.77e-11
R11 N10 N11 2.27e-02
C12 N11 N12 2.73e-06
L12 N11 N12 1.02e-11
R12 N11 N12 6.29e-03
C13 N12 N13 1.12e-06
L13 N12 N13 1.03e-11
R13 N12 N13 8.74e-03
C14 N13 Port2 5.21e-11
L14 N13 Port2 4.51e-12
R14 N13 Port2 2.14e-01
.ENDS LLL153C70E105ME21

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X5R(-55to85[deg])/2.20e-01[uF]/6.3[V]
* Murata P/N :LLL153R60J224ME14
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153R60J224ME14 Port1 Port2
C01 Port1 N01 1.58e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 5.40e-11
R03 N02 N03 9.83e-03
C04 N03 N04 3.40e-06
R04 N03 N04 1.01e+03
C05 N04 N05 6.25e-06
R05 N04 N05 8.60e+01
C06 N05 N06 4.32e-06
R06 N05 N06 2.26e+01
C07 N06 N07 3.31e-06
R07 N06 N07 3.64e+00
C08 N07 N08 2.66e-06
R08 N07 N08 4.49e-01
C09 N08 N09 2.79e-06
R09 N08 N09 4.04e-02
C10 N09 N10 2.27e-06
R10 N09 N10 1.19e-02
L11 N10 N11 1.10e-11
R11 N10 N11 3.73e-02
L12 N11 N12 2.52e-11
R12 N11 N12 2.60e-02
C13 N12 N13 3.07e-07
L13 N12 N13 8.65e-12
R13 N12 N13 1.49e-02
C14 N13 N14 1.12e-07
L14 N13 N14 8.82e-12
R14 N13 N14 2.12e-02
C15 N14 Port2 1.81e-11
L15 N14 Port2 9.44e-12
R15 N14 Port2 5.91e-01
.ENDS LLL153R60J224ME14

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X6S(-55to105[deg])/1.00e-01[uF]/6.3[V]
* Murata P/N :LLL153C80J104ME01
* Property : C = 1.00e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153C80J104ME01 Port1 Port2
C01 Port1 N01 7.96e-08
R01 Port1 N01 5.00e+08
L02 N01 N02 5.18e-11
R03 N02 N03 1.36e-02
C04 N03 N04 1.70e-06
R04 N03 N04 2.35e+03
C05 N04 N05 2.89e-06
R05 N04 N05 1.86e+02
C06 N05 N06 2.07e-06
R06 N05 N06 4.08e+01
C07 N06 N07 1.61e-06
R07 N06 N07 5.19e+00
C08 N07 N08 2.44e-06
R08 N07 N08 5.32e-01
C09 N08 N09 1.94e-06
R09 N08 N09 1.86e-01
C10 N09 N10 1.45e-06
R10 N09 N10 6.93e-02
C11 N10 N11 9.27e-07
R11 N10 N11 2.12e-02
L12 N11 N12 2.43e-11
R12 N11 N12 5.83e-02
L13 N12 N13 2.55e-12
R13 N12 N13 2.41e-02
C14 N13 N14 1.54e-07
L14 N13 N14 6.85e-12
R14 N13 N14 1.94e-02
C15 N14 N15 5.43e-08
L15 N14 N15 6.40e-12
R15 N14 N15 2.63e-02
C16 N15 Port2 1.13e-11
L16 N15 Port2 1.78e-11
R16 N15 Port2 3.98e+00
.ENDS LLL153C80J104ME01

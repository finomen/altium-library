*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/35[V]
* Murata P/N :ZRB157R6YA225ME11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB157R6YA225ME11 Port1 Port2
C01 Port1 N01 1.80e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.70e-10
R03 N02 N03 6.94e-03
C04 N03 N04 1.61e-04
R04 N03 N04 9.37e+00
C05 N04 N05 1.06e-04
R05 N04 N05 7.08e+00
C06 N05 N06 9.37e-05
R06 N05 N06 1.33e+00
C07 N06 N07 9.47e-05
R07 N06 N07 2.76e-01
C08 N07 N08 7.05e-05
R08 N07 N08 6.61e-02
C09 N08 N09 4.79e-05
R09 N08 N09 1.43e-02
L10 N09 N10 3.32e-11
R10 N09 N10 1.07e-01
L11 N10 N11 1.37e-10
R11 N10 N11 1.73e-02
L12 N11 N12 4.98e-11
R12 N11 N12 1.12e-02
C13 N12 N13 1.37e-05
L13 N12 N13 1.76e-11
R13 N12 N13 4.38e-03
C14 N13 N14 2.58e-06
L14 N13 N14 4.36e-11
R14 N13 N14 7.37e-03
C15 N14 Port2 1.50e-11
L15 N14 Port2 1.73e-11
R15 N14 Port2 3.70e-01
.ENDS ZRB157R6YA225ME11

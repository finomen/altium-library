*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/2.20e+00[uF]/25[V]
* Murata P/N :ZRB157R61E225KE11
* Property : C = 2.20e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB157R61E225KE11 Port1 Port2
C01 Port1 N01 1.82e-06
R01 Port1 N01 2.27e+07
L02 N01 N02 2.67e-10
R03 N02 N03 7.17e-03
C04 N03 N04 1.62e-04
R04 N03 N04 9.74e+00
C05 N04 N05 1.14e-04
R05 N04 N05 6.10e+00
C06 N05 N06 9.83e-05
R06 N05 N06 1.23e+00
C07 N06 N07 9.88e-05
R07 N06 N07 2.57e-01
C08 N07 N08 7.51e-05
R08 N07 N08 6.22e-02
C09 N08 N09 4.47e-05
R09 N08 N09 1.50e-02
L10 N09 N10 1.73e-11
R10 N09 N10 2.58e-01
L11 N10 N11 2.80e-11
R11 N10 N11 6.82e-02
L12 N11 N12 1.87e-10
R12 N11 N12 2.59e-02
C13 N12 N13 1.41e-05
L13 N12 N13 1.72e-11
R13 N12 N13 4.44e-03
C14 N13 Port2 2.91e-06
L14 N13 Port2 3.96e-11
R14 N13 Port2 7.13e-03
.ENDS ZRB157R61E225KE11

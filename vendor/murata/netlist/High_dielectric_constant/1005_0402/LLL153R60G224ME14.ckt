*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X5R(-55to85[deg])/2.20e-01[uF]/4[V]
* Murata P/N :LLL153R60G224ME14
* Property : C = 2.20e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153R60G224ME14 Port1 Port2
C01 Port1 N01 1.57e-07
R01 Port1 N01 2.27e+08
L02 N01 N02 4.96e-11
R03 N02 N03 1.04e-02
C04 N03 N04 3.73e-06
R04 N03 N04 3.48e+02
C05 N04 N05 4.33e-06
R05 N04 N05 3.40e+01
C06 N05 N06 3.88e-06
R06 N05 N06 4.91e+00
C07 N06 N07 3.43e-06
R07 N06 N07 7.78e-01
C08 N07 N08 3.35e-06
R08 N07 N08 1.41e-01
C09 N08 N09 2.80e-06
R09 N08 N09 3.36e-02
C10 N09 N10 2.60e-06
R10 N09 N10 1.02e-02
L11 N10 N11 2.91e-11
R11 N10 N11 5.56e-02
L12 N11 N12 2.54e-12
R12 N11 N12 3.14e-02
C13 N12 N13 2.09e-07
L13 N12 N13 1.23e-11
R13 N12 N13 1.96e-02
C14 N13 N14 7.89e-08
L14 N13 N14 1.09e-11
R14 N13 N14 2.20e-02
C15 N14 Port2 1.84e-11
L15 N14 Port2 1.01e-11
R15 N14 Port2 3.06e+00
.ENDS LLL153R60G224ME14

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X5R(-55to85[deg])/1.00e+01[uF]/6.3[V]
* Murata P/N :ZRB15XR60J106ME12
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB15XR60J106ME12 Port1 Port2
C01 Port1 N01 7.85e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.41e-10
R03 N02 N03 7.09e-03
C04 N03 N04 5.13e-04
R04 N03 N04 7.15e+00
C05 N04 N05 6.25e-04
R05 N04 N05 7.66e-01
C06 N05 N06 7.22e-04
R06 N05 N06 1.04e-01
C07 N06 N07 5.67e-04
R07 N06 N07 1.82e-02
C08 N07 N08 3.12e-04
R08 N07 N08 3.10e-03
L09 N08 N09 3.29e-11
R09 N08 N09 1.33e-01
L10 N09 N10 8.29e-11
R10 N09 N10 3.78e-02
L11 N10 N11 2.32e-10
R11 N10 N11 1.73e-02
C12 N11 N12 1.38e-05
L12 N11 N12 5.47e-11
R12 N11 N12 1.85e-03
C13 N12 Port2 9.46e-12
L13 N12 Port2 2.11e-11
R13 N12 Port2 1.72e+00
.ENDS ZRB15XR60J106ME12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7T(-55to125[deg])/1.00e+00[uF]/4[V]
* Murata P/N :LLL152D70G105ME01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL152D70G105ME01 Port1 Port2
C01 Port1 N01 8.83e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.17e-11
R03 N02 N03 4.26e-03
C04 N03 N04 6.77e-05
R04 N03 N04 3.78e+01
C05 N04 N05 7.73e-05
R05 N04 N05 4.46e+00
C06 N05 N06 8.13e-05
R06 N05 N06 6.43e-01
C07 N06 N07 7.94e-05
R07 N06 N07 9.13e-02
C08 N07 N08 5.81e-05
R08 N07 N08 1.77e-02
C09 N08 N09 5.28e-05
R09 N08 N09 3.24e-03
L10 N09 N10 4.08e-12
R10 N09 N10 2.03e-01
L11 N10 N11 1.10e-11
R11 N10 N11 4.20e-02
L12 N11 N12 3.80e-11
R12 N11 N12 2.09e-02
C13 N12 N13 1.62e-06
L13 N12 N13 1.19e-11
R13 N12 N13 5.83e-03
C14 N13 Port2 4.65e-07
L14 N13 Port2 1.30e-11
R14 N13 Port2 6.13e-03
.ENDS LLL152D70G105ME01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7S(-55to125[deg])/4.70e-01[uF]/2.5[V]
* Murata P/N :LLL153C70E474ME17
* Property : C = 4.70e-01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153C70E474ME17 Port1 Port2
C01 Port1 N01 4.60e-07
R01 Port1 N01 1.06e+08
L02 N01 N02 2.89e-11
R03 N02 N03 4.24e-03
C04 N03 N04 1.44e-05
R04 N03 N04 2.76e+02
C05 N04 N05 2.58e-05
R05 N04 N05 2.24e+01
C06 N05 N06 2.35e-05
R06 N05 N06 4.47e+00
C07 N06 N07 2.89e-05
R07 N06 N07 5.51e-01
C08 N07 N08 3.45e-05
R08 N07 N08 5.02e-02
C09 N08 N09 2.79e-05
R09 N08 N09 1.16e-02
L10 N09 N10 1.80e-11
R10 N09 N10 4.49e+00
L11 N10 N11 5.28e-12
R11 N10 N11 3.87e-02
L12 N11 N12 4.34e-11
R12 N11 N12 3.12e-02
C13 N12 N13 1.02e-06
L13 N12 N13 1.17e-11
R13 N12 N13 8.86e-03
C14 N13 N14 3.57e-07
L14 N13 N14 1.26e-11
R14 N13 N14 1.32e-02
C15 N14 Port2 2.70e-11
L15 N14 Port2 1.00e-11
R15 N14 Port2 7.00e+00
.ENDS LLL153C70E474ME17

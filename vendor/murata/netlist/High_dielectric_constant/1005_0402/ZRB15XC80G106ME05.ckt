*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+01[uF]/4[V]
* Murata P/N :ZRB15XC80G106ME05
* Property : C = 1.00e+01[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT ZRB15XC80G106ME05 Port1 Port2
C01 Port1 N01 6.55e-06
R01 Port1 N01 5.00e+06
L02 N01 N02 2.27e-10
R03 N02 N03 4.88e-03
C04 N03 N04 4.30e-04
R04 N03 N04 4.26e+00
C05 N04 N05 5.86e-04
R05 N04 N05 6.47e-01
C06 N05 N06 5.24e-04
R06 N05 N06 1.45e-01
C07 N06 N07 5.54e-04
R07 N06 N07 2.28e-02
C08 N07 N08 3.35e-04
R08 N07 N08 5.01e-03
L09 N08 N09 3.59e-11
R09 N08 N09 1.02e-01
L10 N09 N10 9.34e-11
R10 N09 N10 2.72e-02
L11 N10 N11 2.19e-10
R11 N10 N11 1.20e-02
C12 N11 N12 6.88e-05
L12 N11 N12 1.79e-11
R12 N11 N12 1.54e-03
C13 N12 N13 1.27e-05
L13 N12 N13 4.21e-11
R13 N12 N13 2.61e-03
C14 N13 Port2 1.15e-11
L14 N13 Port2 1.77e-11
R14 N13 Port2 7.81e-01
.ENDS ZRB15XC80G106ME05

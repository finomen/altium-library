*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R(-55to125[deg])/5.60e-02[uF]/50[V]
* Murata P/N :GRT155R71H563KE01
* Property : C = 5.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155R71H563KE01 Port1 Port2
C01 Port1 N01 5.43e-08
R01 Port1 N01 8.93e+08
L02 N01 N02 2.17e-10
R03 N02 N03 3.93e-02
C04 N03 N04 8.38e-06
R04 N03 N04 2.68e+02
C05 N04 N05 9.41e-06
R05 N04 N05 5.57e+01
C06 N05 N06 8.55e-06
R06 N05 N06 1.23e+01
C07 N06 N07 7.91e-06
R07 N06 N07 2.73e+00
C08 N07 N08 6.58e-06
R08 N07 N08 6.24e-01
C09 N08 N09 4.74e-06
R09 N08 N09 1.51e-01
C10 N09 N10 2.81e-06
R10 N09 N10 3.42e-02
L11 N10 N11 9.67e-11
R11 N10 N11 5.12e+00
L12 N11 N12 8.09e-11
R12 N11 N12 1.17e-01
C13 N12 N13 9.97e-07
L13 N12 N13 4.42e-12
R13 N12 N13 5.77e-03
C14 N13 Port2 1.11e-07
L14 N13 Port2 1.60e-11
R14 N13 Port2 1.78e-02
.ENDS GRT155R71H563KE01

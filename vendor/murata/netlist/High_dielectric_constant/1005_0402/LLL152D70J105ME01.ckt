*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7T(-55to125[deg])/1.00e+00[uF]/6.3[V]
* Murata P/N :LLL152D70J105ME01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL152D70J105ME01 Port1 Port2
C01 Port1 N01 8.89e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.02e-11
R03 N02 N03 4.28e-03
C04 N03 N04 8.69e-05
R04 N03 N04 9.07e+00
C05 N04 N05 8.44e-05
R05 N04 N05 1.48e+00
C06 N05 N06 8.15e-05
R06 N05 N06 2.28e-01
C07 N06 N07 6.25e-05
R07 N06 N07 3.58e-02
C08 N07 N08 4.96e-05
R08 N07 N08 5.35e-03
L09 N08 N09 8.78e-12
R09 N08 N09 5.96e-01
L10 N09 N10 8.05e-12
R10 N09 N10 3.82e-02
L11 N10 N11 2.92e-11
R11 N10 N11 2.85e-02
C12 N11 N12 1.63e-06
L12 N11 N12 1.15e-11
R12 N11 N12 5.45e-03
C13 N12 Port2 2.01e-07
L13 N12 Port2 2.43e-11
R13 N12 Port2 9.56e-03
.ENDS LLL152D70J105ME01

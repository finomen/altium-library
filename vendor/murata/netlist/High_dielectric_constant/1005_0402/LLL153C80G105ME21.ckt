*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X6S(-55to105[deg])/1.00e+00[uF]/4[V]
* Murata P/N :LLL153C80G105ME21
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL153C80G105ME21 Port1 Port2
C01 Port1 N01 8.44e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.39e-11
R03 N02 N03 3.44e-03
C04 N03 N04 3.15e-05
R04 N03 N04 5.62e+01
C05 N04 N05 3.54e-05
R05 N04 N05 5.86e+00
C06 N05 N06 3.52e-05
R06 N05 N06 7.04e-01
C07 N06 N07 3.79e-05
R07 N06 N07 6.63e-02
C08 N07 N08 5.09e-05
R08 N07 N08 6.77e-03
L09 N08 N09 8.75e-12
R09 N08 N09 4.67e-01
L10 N09 N10 8.43e-12
R10 N09 N10 4.20e-02
L11 N10 N11 5.37e-11
R11 N10 N11 2.23e-02
C12 N11 N12 1.89e-06
L12 N11 N12 1.33e-11
R12 N11 N12 7.06e-03
C13 N12 Port2 7.87e-07
L13 N12 Port2 1.28e-11
R13 N12 Port2 8.91e-03
.ENDS LLL153C80G105ME21

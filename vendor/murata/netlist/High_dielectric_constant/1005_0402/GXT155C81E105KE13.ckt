*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/1.00e+00[uF]/25[V]
* Murata P/N :GXT155C81E105KE13
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GXT155C81E105KE13 Port1 Port2
C01 Port1 N01 6.73e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.81e-10
R03 N02 N03 9.31e-03
C04 N03 N04 6.75e-05
R04 N03 N04 3.57e+01
C05 N04 N05 7.54e-05
R05 N04 N05 5.40e+00
C06 N05 N06 4.87e-05
R06 N05 N06 1.63e+00
C07 N06 N07 3.71e-05
R07 N06 N07 3.86e-01
C08 N07 N08 2.61e-05
R08 N07 N08 7.30e-02
C09 N08 N09 1.66e-05
R09 N08 N09 1.37e-02
L10 N09 N10 9.72e-12
R10 N09 N10 1.40e-01
L11 N10 N11 3.25e-11
R11 N10 N11 1.04e-01
L12 N11 N12 1.44e-10
R12 N11 N12 3.23e-02
C13 N12 N13 4.60e-06
L13 N12 N13 1.55e-11
R13 N12 N13 3.88e-03
C14 N13 N14 2.28e-06
L14 N13 N14 1.65e-11
R14 N13 N14 5.10e-03
C15 N14 Port2 2.71e-11
L15 N14 Port2 1.15e-11
R15 N14 Port2 1.74e+00
.ENDS GXT155C81E105KE13

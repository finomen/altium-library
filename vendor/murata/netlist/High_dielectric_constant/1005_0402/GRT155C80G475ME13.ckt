*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X6S(-55to105[deg])/4.70e+00[uF]/4[V]
* Murata P/N :GRT155C80G475ME13
* Property : C = 4.70e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT155C80G475ME13 Port1 Port2
C01 Port1 N01 3.93e-06
R01 Port1 N01 1.06e+07
L02 N01 N02 1.23e-10
R03 N02 N03 8.46e-03
C04 N03 N04 1.98e-04
R04 N03 N04 2.03e+01
C05 N04 N05 2.86e-04
R05 N04 N05 1.57e+00
C06 N05 N06 3.67e-04
R06 N05 N06 1.55e-01
C07 N06 N07 4.04e-04
R07 N06 N07 1.58e-02
C08 N07 N08 4.27e-04
R08 N07 N08 1.50e-03
L09 N08 N09 4.05e-11
R09 N08 N09 2.14e-01
L10 N09 N10 6.57e-11
R10 N09 N10 3.40e-02
L11 N10 N11 2.09e-10
R11 N10 N11 1.27e-02
C12 N11 N12 1.30e-05
L12 N11 N12 2.24e-11
R12 N11 N12 1.24e-03
C13 N12 N13 1.82e-06
L13 N12 N13 8.47e-11
R13 N12 N13 8.16e-04
C14 N13 Port2 6.75e-12
L14 N13 Port2 4.01e-11
R14 N13 Port2 8.50e+00
.ENDS GRT155C80G475ME13

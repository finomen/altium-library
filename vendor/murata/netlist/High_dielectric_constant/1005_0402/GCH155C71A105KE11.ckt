*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7S(-55to125[deg])/1.00e+00[uF]/10[V]
* Murata P/N :GCH155C71A105KE11
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH155C71A105KE11 Port1 Port2
C01 Port1 N01 7.92e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 1.20e-10
R03 N02 N03 1.38e-02
C04 N03 N04 3.56e-05
R04 N03 N04 1.04e+02
C05 N04 N05 3.71e-05
R05 N04 N05 1.06e+01
C06 N05 N06 3.82e-05
R06 N05 N06 1.39e+00
C07 N06 N07 3.73e-05
R07 N06 N07 2.24e-01
C08 N07 N08 3.21e-05
R08 N07 N08 4.93e-02
C09 N08 N09 2.13e-05
R09 N08 N09 1.18e-02
L10 N09 N10 3.86e-11
R10 N09 N10 2.57e-01
L11 N10 N11 2.42e-11
R11 N10 N11 3.56e-02
L12 N11 N12 1.39e-10
R12 N11 N12 2.84e-02
C13 N12 N13 2.89e-06
L13 N12 N13 2.47e-11
R13 N12 N13 3.73e-03
C14 N13 N14 2.76e-06
L14 N13 N14 1.42e-11
R14 N13 N14 2.77e-03
C15 N14 Port2 2.64e-12
L15 N14 Port2 9.47e-11
R15 N14 Port2 2.28e+01
.ENDS GCH155C71A105KE11

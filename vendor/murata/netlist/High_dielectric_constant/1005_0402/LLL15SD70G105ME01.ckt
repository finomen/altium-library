*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0510M(0204)/X7T(-55to125[deg])/1.00e+00[uF]/4[V]
* Murata P/N :LLL15SD70G105ME01
* Property : C = 1.00e+00[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[Hz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT LLL15SD70G105ME01 Port1 Port2
C01 Port1 N01 8.50e-07
R01 Port1 N01 5.00e+07
L02 N01 N02 4.77e-11
R03 N02 N03 4.79e-03
C04 N03 N04 7.73e-05
R04 N03 N04 2.49e+01
C05 N04 N05 8.56e-05
R05 N04 N05 5.43e+00
C06 N05 N06 8.24e-05
R06 N05 N06 1.07e+00
C07 N06 N07 8.17e-05
R07 N06 N07 1.94e-01
C08 N07 N08 6.24e-05
R08 N07 N08 3.86e-02
C09 N08 N09 4.23e-05
R09 N08 N09 7.47e-03
L10 N09 N10 5.22e-12
R10 N09 N10 1.83e-01
L11 N10 N11 9.70e-12
R11 N10 N11 3.77e-02
L12 N11 N12 3.28e-11
R12 N11 N12 1.66e-02
L13 N12 N13 1.61e-11
R13 N12 N13 5.96e-03
C14 N13 N14 2.02e-06
L14 N13 N14 7.95e-12
R14 N13 N14 4.63e-03
C15 N14 Port2 1.49e-06
L15 N14 Port2 3.64e-12
R15 N14 Port2 3.22e-03
.ENDS LLL15SD70G105ME01

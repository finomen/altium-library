*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/2.20e-02[uF]/250[Vac]
* Murata P/N :GA355DR7GB223KW01
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355DR7GB223KW01 Port1 Port2
C01 Port1 N01 2.37e-08
R01 Port1 N01 6.00e+09
L02 N01 N02 1.11e-10
R03 N02 N03 2.10e-02
C04 N03 N04 1.54e-06
R04 N03 N04 1.03e+00
C05 N04 N05 1.69e-06
R05 N04 N05 1.22e-01
C06 N05 N06 8.37e-07
R06 N05 N06 2.22e-02
L07 N06 N07 1.29e-10
R07 N06 N07 3.86e-01
C08 N07 N08 4.18e-08
L08 N07 N08 9.63e-11
R08 N07 N08 2.23e-01
C09 N08 N09 1.19e-08
L09 N08 N09 7.11e-11
R09 N08 N09 1.68e-01
C10 N09 Port2 6.44e-12
L10 N09 Port2 4.42e-10
R10 N09 Port2 5.10e+01
.ENDS GA355DR7GB223KW01

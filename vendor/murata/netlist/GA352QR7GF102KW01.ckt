*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/1.00e-03[uF]/250[Vac]
* Murata P/N :GA352QR7GF102KW01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF102KW01 Port1 Port2
C01 Port1 N01 1.21e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 1.17e-10
R03 N02 N03 2.03e-01
C04 N03 N04 7.06e-09
R04 N03 N04 7.13e+02
C05 N04 N05 2.04e-07
R05 N04 N05 3.90e+00
C06 N05 N06 1.43e-07
R06 N05 N06 1.23e+00
C07 N06 N07 1.12e-07
R07 N06 N07 4.72e-01
C08 N07 N08 8.00e-08
R08 N07 N08 2.84e-01
C09 N08 N09 1.30e-08
R09 N08 N09 2.43e-01
L10 N09 N10 3.43e-10
R10 N09 N10 4.09e+00
C11 N10 N11 5.07e-09
L11 N10 N11 3.98e-11
R11 N10 N11 4.52e-01
C12 N11 Port2 2.98e-12
L12 N11 Port2 6.31e-10
R12 N11 Port2 5.65e+01
.ENDS GA352QR7GF102KW01

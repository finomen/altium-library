*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/X7R(-55to125[deg])/4.70e-03[uF]/250[Vac]
* Murata P/N :GA355DR7GF472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA355DR7GF472KW01 Port1 Port2
C01 Port1 N01 4.55e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 8.09e-11
R03 N02 N03 6.50e-02
C04 N03 N04 1.25e-07
R04 N03 N04 2.54e+01
C05 N04 N05 3.50e-07
R05 N04 N05 6.02e-01
C06 N05 N06 3.32e-07
R06 N05 N06 1.05e-01
C07 N06 N07 1.09e-07
R07 N06 N07 5.79e-02
L08 N07 N08 1.69e-10
R08 N07 N08 1.01e+00
C09 N08 N09 6.95e-09
L09 N08 N09 1.21e-10
R09 N08 N09 5.59e-01
C10 N09 N10 2.46e-09
L10 N09 N10 6.82e-11
R10 N09 N10 3.62e-01
C11 N10 Port2 6.95e-12
L11 N10 Port2 2.96e-10
R11 N10 Port2 4.14e+01
.ENDS GA355DR7GF472KW01

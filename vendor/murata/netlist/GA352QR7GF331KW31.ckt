*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/3.30e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF331KW31
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF331KW31 Port1 Port2
C01 Port1 N01 3.15e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 7.39e-11
R03 N02 N03 3.77e-02
C04 N03 N04 4.18e-10
L04 N03 N04 1.65e-10
R04 N03 N04 6.64e+00
C05 N04 N05 2.96e-10
L05 N04 N05 8.50e-11
R05 N04 N05 5.75e+00
C06 N05 Port2 1.28e-12
L06 N05 Port2 7.06e-10
R06 N05 Port2 1.71e+02
.ENDS GA352QR7GF331KW31

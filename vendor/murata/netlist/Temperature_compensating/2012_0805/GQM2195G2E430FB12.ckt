*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E430FB12
* Property : C = 4.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E430FB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 3.72e-02
L04 N03 N04 5.27e-12
R04 N03 N04 1.82e-02
C05 N04 N05 9.86e-11
L05 N04 N05 3.82e-11
R05 N04 N05 3.04e+01
C06 N05 N06 4.18e-11
L06 N05 N06 3.57e-11
R06 N05 N06 3.99e+01
C07 N06 N07 5.72e-11
L07 N06 N07 1.27e-11
R07 N06 N07 1.97e+01
C08 N07 N08 1.43e-11
L08 N07 N08 3.19e-11
R08 N07 N08 6.48e+01
C09 N08 N09 4.32e-12
L09 N08 N09 7.25e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 8.52e-12
L10 N09 Port2 3.65e-11
R10 N09 Port2 6.98e+01
.ENDS GQM2195G2E430FB12

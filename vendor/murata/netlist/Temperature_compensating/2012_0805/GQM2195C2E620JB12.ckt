*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E620JB12
* Property : C = 6.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E620JB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 3.31e-02
L04 N03 N04 4.82e-12
R04 N03 N04 1.61e-02
C05 N04 N05 1.06e-10
L05 N04 N05 5.23e-11
R05 N04 N05 3.90e+01
C06 N05 N06 5.86e-11
L06 N05 N06 3.72e-11
R06 N05 N06 3.44e+01
C07 N06 N07 7.81e-11
L07 N06 N07 1.34e-11
R07 N06 N07 1.52e+01
C08 N07 N08 3.65e-11
L08 N07 N08 1.77e-11
R08 N07 N08 2.53e+01
C09 N08 N09 3.72e-11
L09 N08 N09 1.15e-11
R09 N08 N09 2.62e+01
C10 N09 N10 4.49e-11
L10 N09 N10 7.69e-12
R10 N09 N10 3.00e+01
C11 N10 Port2 2.62e-12
L11 N10 Port2 1.15e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E620JB12

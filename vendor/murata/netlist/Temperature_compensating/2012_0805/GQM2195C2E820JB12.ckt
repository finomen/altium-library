*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E820JB12
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E820JB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.38e-12
R03 N02 N03 3.30e-02
L04 N03 N04 4.74e-12
R04 N03 N04 2.98e-02
C05 N04 N05 1.84e-10
L05 N04 N05 4.04e-11
R05 N04 N05 2.17e+01
C06 N05 N06 8.29e-11
L06 N05 N06 3.51e-11
R06 N05 N06 2.66e+01
C07 N06 N07 1.46e-10
L07 N06 N07 9.59e-12
R07 N06 N07 9.61e+00
C08 N07 N08 5.71e-11
L08 N07 N08 1.50e-11
R08 N07 N08 1.68e+01
C09 N08 N09 8.90e-11
L09 N08 N09 6.32e-12
R09 N08 N09 8.72e+00
C10 N09 N10 3.40e-11
L10 N09 N10 1.20e-11
R10 N09 N10 2.22e+01
C11 N10 Port2 7.57e-13
L11 N10 Port2 2.81e-10
R11 N10 Port2 1.00e+05
.ENDS GQM2195C2E820JB12

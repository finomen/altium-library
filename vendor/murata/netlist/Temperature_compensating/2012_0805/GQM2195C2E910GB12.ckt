*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E910GB12
* Property : C = 9.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E910GB12 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.24e-10
R03 N02 N03 3.00e-02
L04 N03 N04 3.65e-12
R04 N03 N04 1.41e-02
C05 N04 N05 1.87e-10
L05 N04 N05 4.38e-11
R05 N04 N05 1.87e+01
C06 N05 N06 9.45e-11
L06 N05 N06 3.29e-11
R06 N05 N06 2.05e+01
C07 N06 N07 1.54e-10
L07 N06 N07 9.75e-12
R07 N06 N07 8.41e+00
C08 N07 N08 6.13e-11
L08 N07 N08 1.51e-11
R08 N07 N08 1.61e+01
C09 N08 N09 7.88e-11
L09 N08 N09 7.74e-12
R09 N08 N09 1.17e+01
C10 N09 N10 1.52e-11
L10 N09 N10 2.96e-11
R10 N09 N10 5.27e+01
C11 N10 Port2 2.81e-12
L11 N10 Port2 1.27e-10
R11 N10 Port2 3.10e+02
.ENDS GQM2195C2E910GB12

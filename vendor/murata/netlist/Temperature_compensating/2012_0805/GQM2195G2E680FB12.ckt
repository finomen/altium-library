*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM2195G2E680FB12
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E680FB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 3.09e-02
L04 N03 N04 6.94e-12
R04 N03 N04 9.02e-02
C05 N04 N05 1.47e-10
L05 N04 N05 4.17e-11
R05 N04 N05 2.38e+01
C06 N05 N06 6.72e-11
L06 N05 N06 3.55e-11
R06 N05 N06 3.08e+01
C07 N06 N07 1.01e-10
L07 N06 N07 1.14e-11
R07 N06 N07 1.32e+01
C08 N07 N08 3.63e-11
L08 N07 N08 1.96e-11
R08 N07 N08 2.72e+01
C09 N08 N09 6.25e-11
L09 N08 N09 7.50e-12
R09 N08 N09 1.66e+01
C10 N09 Port2 2.73e-12
L10 N09 Port2 1.23e-10
R10 N09 Port2 9.29e+02
.ENDS GQM2195G2E680FB12

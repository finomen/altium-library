*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.10e-05[uF]/250[V]
* Murata P/N :GQM2195C2E510GB12
* Property : C = 5.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E510GB12 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 3.51e-02
L04 N03 N04 5.55e-12
R04 N03 N04 1.54e-02
C05 N04 N05 1.04e-10
L05 N04 N05 4.41e-11
R05 N04 N05 3.14e+01
C06 N05 N06 5.00e-11
L06 N05 N06 3.52e-11
R06 N05 N06 4.30e+01
C07 N06 N07 6.49e-11
L07 N06 N07 1.31e-11
R07 N06 N07 1.83e+01
C08 N07 N08 1.99e-11
L08 N07 N08 2.67e-11
R08 N07 N08 5.25e+01
C09 N08 N09 4.64e-12
L09 N08 N09 7.55e-11
R09 N08 N09 1.97e+02
C10 N09 Port2 3.89e-12
L10 N09 Port2 8.19e-11
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E510GB12

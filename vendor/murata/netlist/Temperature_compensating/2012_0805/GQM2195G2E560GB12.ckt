*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM2195G2E560GB12
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E560GB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.36e-12
R04 N03 N04 2.74e-02
C05 N04 N05 1.30e-10
L05 N04 N05 3.85e-11
R05 N04 N05 2.83e+01
C06 N05 N06 5.82e-11
L06 N05 N06 3.32e-11
R06 N05 N06 4.04e+01
C07 N06 N07 8.27e-11
L07 N06 N07 1.13e-11
R07 N06 N07 1.72e+01
C08 N07 N08 3.70e-11
L08 N07 N08 1.55e-11
R08 N07 N08 3.37e+01
C09 N08 N09 3.66e-11
L09 N08 N09 1.03e-11
R09 N08 N09 2.32e+01
C10 N09 Port2 1.64e-12
L10 N09 Port2 1.52e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195G2E560GB12

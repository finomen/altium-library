*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R1DB12
* Property : C = 1.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R1DB12 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.94e-10
R03 N02 N03 1.75e-01
L04 N03 N04 2.75e-12
R04 N03 N04 1.73e-01
C05 N04 N05 4.28e-12
L05 N04 N05 5.81e-11
C06 N05 Port2 1.18e-09
L06 N05 Port2 2.90e-13
R06 N05 Port2 6.71e-01
.ENDS GQM2195G2E1R1DB12

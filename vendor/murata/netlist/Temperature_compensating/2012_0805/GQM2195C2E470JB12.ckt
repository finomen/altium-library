*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM2195C2E470JB12
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E470JB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.04e-10
R03 N02 N03 3.78e-02
L04 N03 N04 3.31e-12
R04 N03 N04 3.31e-02
C05 N04 N05 1.06e-10
L05 N04 N05 4.03e-11
R05 N04 N05 2.90e+01
C06 N05 N06 4.63e-11
L06 N05 N06 3.61e-11
R06 N05 N06 3.81e+01
C07 N06 N07 8.14e-11
L07 N06 N07 9.93e-12
R07 N06 N07 1.48e+01
C08 N07 N08 2.90e-11
L08 N07 N08 1.72e-11
R08 N07 N08 3.64e+01
C09 N08 N09 2.66e-11
L09 N08 N09 1.22e-11
R09 N08 N09 9.36e+00
C10 N09 Port2 1.43e-12
L10 N09 Port2 1.74e-10
R10 N09 Port2 1.00e+05
.ENDS GQM2195C2E470JB12

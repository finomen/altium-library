*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-06[uF]/500[V]
* Murata P/N :GQM2195G2H7R5DB12
* Property : C = 7.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.75e-12
R04 N03 N04 3.30e-02
L05 N04 N05 2.21e-12
R05 N04 N05 8.32e-02
C06 N05 N06 2.48e-12
L06 N05 N06 1.20e-10
C07 N06 N07 5.10e-11
L07 N06 N07 6.87e-12
R07 N06 N07 3.02e+00
C08 N07 Port2 1.34e-11
L08 N07 Port2 5.76e-11
R08 N07 Port2 1.44e+02
.ENDS GQM2195G2H7R5DB12

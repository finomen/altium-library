*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E100GB12
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E100GB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.01e-11
R03 N02 N03 3.51e-02
L04 N03 N04 3.12e-12
R04 N03 N04 5.39e-02
C05 N04 N05 1.82e-11
L05 N04 N05 5.51e-11
R05 N04 N05 1.14e+02
C06 N05 N06 3.83e-12
L06 N05 N06 9.38e-11
R06 N05 N06 5.32e+02
C07 N06 Port2 1.48e-12
L07 N06 Port2 1.68e-10
R07 N06 Port2 1.00e+05
.ENDS GQM2195G2E100GB12

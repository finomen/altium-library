*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.20e-03[uF]/25[V]
* Murata P/N :GRT2165C1E222JA12
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C1E222JA12 Port1 Port2
C01 Port1 N01 2.15e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 4.23e-10
R03 N02 N03 4.67e-03
L04 N03 N04 5.28e-11
R04 N03 N04 3.98e-01
L05 N04 N05 7.02e-11
R05 N04 N05 1.95e-02
L06 N05 N06 2.50e-10
R06 N05 N06 7.34e-03
C07 N06 N07 1.21e-08
L07 N06 N07 1.69e-11
R07 N06 N07 2.38e-01
C08 N07 N08 2.26e-09
L08 N07 N08 3.51e-11
R08 N07 N08 5.10e-01
C09 N08 Port2 5.40e-12
L09 N08 Port2 2.94e-11
R09 N08 Port2 1.51e+00
.ENDS GRT2165C1E222JA12

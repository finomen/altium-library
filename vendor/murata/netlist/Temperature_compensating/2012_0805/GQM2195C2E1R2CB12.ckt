*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM2195C2E1R2CB12
* Property : C = 1.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E1R2CB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-10
R03 N02 N03 1.70e-01
C04 N03 N04 4.23e-12
L04 N03 N04 5.87e-11
C05 N04 Port2 8.07e-10
L05 N04 Port2 4.34e-13
R05 N04 Port2 1.91e-01
.ENDS GQM2195C2E1R2CB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM2195G2E101JB12
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E101JB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-11
R03 N02 N03 3.00e-02
L04 N03 N04 1.99e-11
R04 N03 N04 1.21e+00
C05 N04 N05 2.11e-10
L05 N04 N05 4.18e-11
R05 N04 N05 1.74e+01
C06 N05 N06 9.71e-11
L06 N05 N06 3.47e-11
R06 N05 N06 1.99e+01
C07 N06 N07 1.74e-10
L07 N06 N07 9.35e-12
R07 N06 N07 7.40e+00
C08 N07 N08 7.35e-11
L08 N07 N08 1.36e-11
R08 N07 N08 1.38e+01
C09 N08 N09 1.17e-10
L09 N08 N09 5.62e-12
R09 N08 N09 6.83e+00
C10 N09 N10 4.40e-11
L10 N09 N10 1.09e-11
R10 N09 N10 1.51e+01
C11 N10 N11 4.60e-11
L11 N10 N11 7.84e-12
R11 N10 N11 9.33e+00
C12 N11 Port2 1.02e-12
L12 N11 Port2 2.29e-10
R12 N11 Port2 1.00e+05
.ENDS GQM2195G2E101JB12

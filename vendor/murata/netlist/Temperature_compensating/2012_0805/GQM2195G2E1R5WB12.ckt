*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.50e-06[uF]/250[V]
* Murata P/N :GQM2195G2E1R5WB12
* Property : C = 1.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E1R5WB12 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-10
R03 N02 N03 1.10e-01
C04 N03 N04 8.80e-12
L04 N03 N04 3.50e-11
C05 N04 Port2 1.32e-10
L05 N04 Port2 2.46e-12
R05 N04 Port2 3.10e-01
.ENDS GQM2195G2E1R5WB12

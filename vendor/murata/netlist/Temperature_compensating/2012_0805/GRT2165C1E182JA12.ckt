*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.80e-03[uF]/25[V]
* Murata P/N :GRT2165C1E182JA12
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1000[kHz]-6[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRT2165C1E182JA12 Port1 Port2
C01 Port1 N01 1.80e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.51e-10
R03 N02 N03 6.16e-03
L04 N03 N04 4.12e-11
R04 N03 N04 4.32e-01
L05 N04 N05 5.52e-11
R05 N04 N05 3.20e-02
L06 N05 N06 1.22e-10
R06 N05 N06 8.50e-03
C07 N06 N07 8.23e-09
L07 N06 N07 1.57e-11
R07 N06 N07 2.33e-01
C08 N07 N08 1.52e-09
L08 N07 N08 2.95e-11
R08 N07 N08 4.45e-01
C09 N08 Port2 1.22e-12
L09 N08 Port2 2.55e-10
R09 N08 Port2 9.11e+01
.ENDS GRT2165C1E182JA12

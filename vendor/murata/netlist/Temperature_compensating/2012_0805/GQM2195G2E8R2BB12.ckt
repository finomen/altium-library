*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R2BB12
* Property : C = 8.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R2BB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 4.00e-02
C04 N03 N04 3.00e-12
L04 N03 N04 1.04e-10
C05 N04 N05 1.40e-11
L05 N04 N05 5.94e-11
R05 N04 N05 1.38e+02
C06 N05 Port2 8.50e-12
L06 N05 Port2 3.90e-11
R06 N05 Port2 3.75e+01
.ENDS GQM2195G2E8R2BB12

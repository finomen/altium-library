*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E200FB12
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E200FB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 3.55e-02
L04 N03 N04 5.79e-12
R04 N03 N04 3.64e-02
C05 N04 N05 3.69e-11
L05 N04 N05 5.10e-11
R05 N04 N05 8.64e+01
C06 N05 N06 1.74e-11
L06 N05 N06 4.27e-11
R06 N05 N06 8.56e+01
C07 N06 Port2 1.10e-11
L07 N06 Port2 3.33e-11
R07 N06 Port2 1.23e+02
.ENDS GQM2195G2E200FB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM2195G2E5R6WB12
* Property : C = 5.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E5R6WB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 3.50e-02
L04 N03 N04 6.65e-12
R04 N03 N04 1.67e-01
C05 N04 N05 2.45e-12
L05 N04 N05 1.11e-10
C06 N05 N06 1.44e-10
L06 N05 N06 2.31e-12
R06 N05 N06 7.34e-01
C07 N06 Port2 7.44e-12
L07 N06 Port2 7.26e-11
R07 N06 Port2 2.54e+02
.ENDS GQM2195G2E5R6WB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E7R0DB12
* Property : C = 7.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E7R0DB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 7.89e-11
R03 N02 N03 4.00e-02
L04 N03 N04 3.42e-12
R04 N03 N04 2.15e-02
C05 N04 N05 1.61e-12
L05 N04 N05 1.95e-10
R05 N04 N05 7.70e+02
C06 N05 Port2 9.71e-12
L06 N05 Port2 7.38e-11
R06 N05 Port2 2.05e+02
.ENDS GQM2195G2E7R0DB12

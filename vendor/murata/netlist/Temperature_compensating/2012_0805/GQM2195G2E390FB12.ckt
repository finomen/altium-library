*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM2195G2E390FB12
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E390FB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 3.30e-02
L04 N03 N04 4.20e-12
R04 N03 N04 2.64e-02
C05 N04 N05 7.96e-11
L05 N04 N05 4.38e-11
R05 N04 N05 3.55e+01
C06 N05 N06 3.43e-11
L06 N05 N06 3.94e-11
R06 N05 N06 4.71e+01
C07 N06 N07 5.32e-11
L07 N06 N07 1.24e-11
R07 N06 N07 2.11e+01
C08 N07 N08 1.83e-11
L08 N07 N08 2.27e-11
R08 N07 N08 5.16e+01
C09 N08 Port2 7.24e-12
L09 N08 Port2 4.37e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195G2E390FB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/4.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E4R7CB12
* Property : C = 4.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E4R7CB12 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.00e-11
R03 N02 N03 4.00e-02
L04 N03 N04 4.29e-12
R04 N03 N04 1.26e-01
C05 N04 N05 1.79e-12
L05 N04 N05 1.45e-10
R05 N04 N05 8.00e+02
C06 N05 Port2 4.24e-12
L06 N05 Port2 1.12e-10
R06 N05 Port2 6.70e+02
.ENDS GQM2195C2E4R7CB12

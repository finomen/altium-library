*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM2195G2E6R2BB12
* Property : C = 6.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E6R2BB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.18e-12
R04 N03 N04 1.73e-01
C05 N04 N05 1.53e-12
L05 N04 N05 1.77e-10
C06 N05 N06 9.18e-11
L06 N05 N06 3.73e-12
R06 N05 N06 1.68e+00
C07 N06 Port2 7.52e-12
L07 N06 Port2 7.97e-11
R07 N06 Port2 2.64e+02
.ENDS GQM2195G2E6R2BB12

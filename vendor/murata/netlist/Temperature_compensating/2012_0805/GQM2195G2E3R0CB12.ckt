*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E3R0CB12
* Property : C = 3.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 5.00e-02
L04 N03 N04 6.38e-12
R04 N03 N04 3.67e-01
C05 N04 Port2 2.20e-12
L05 N04 Port2 1.60e-10
R05 N04 Port2 2.41e+03
.ENDS GQM2195G2E3R0CB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-05[uF]/250[V]
* Murata P/N :GQM2195C2E120GB12
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E120GB12 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 3.95e-02
L04 N03 N04 2.72e-12
R04 N03 N04 2.38e-01
L05 N04 N05 3.33e-12
R05 N04 N05 5.45e-02
C06 N05 N06 2.01e-11
L06 N05 N06 5.44e-11
R06 N05 N06 1.08e+02
C07 N06 N07 7.81e-12
L07 N06 N07 5.58e-11
R07 N06 N07 1.71e+02
C08 N07 N08 1.58e-10
L08 N07 N08 1.86e-12
R08 N07 N08 1.08e+00
C09 N08 Port2 4.96e-12
L09 N08 Port2 5.88e-11
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E120GB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H2R0CB12
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H2R0CB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.33e-10
R03 N02 N03 8.00e-02
C04 N03 N04 7.50e-12
L04 N03 N04 4.40e-11
C05 N04 Port2 3.45e-11
L05 N04 Port2 9.32e-12
R05 N04 Port2 3.85e+00
.ENDS GQM2195G2H2R0CB12

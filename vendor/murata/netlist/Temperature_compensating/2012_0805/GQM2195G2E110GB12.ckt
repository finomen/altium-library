*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM2195G2E110GB12
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E110GB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.33e-10
R03 N02 N03 3.83e-02
L04 N03 N04 3.82e-12
R04 N03 N04 2.17e-02
C05 N04 N05 1.63e-11
L05 N04 N05 6.32e-11
R05 N04 N05 1.16e+02
C06 N05 N06 4.16e-12
L06 N05 N06 1.07e-10
R06 N05 N06 3.25e+02
C07 N06 Port2 3.98e-12
L07 N06 Port2 7.40e-11
R07 N06 Port2 3.14e+02
.ENDS GQM2195G2E110GB12

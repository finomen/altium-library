*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/6.80e-06[uF]/250[V]
* Murata P/N :GQM2195C2E6R8DB12
* Property : C = 6.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E6R8DB12 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 4.00e-02
L04 N03 N04 5.84e-12
R04 N03 N04 3.67e-02
C05 N04 N05 1.59e-12
L05 N04 N05 1.86e-10
C06 N05 N06 1.42e-11
L06 N05 N06 2.33e-11
R06 N05 N06 2.24e+01
C07 N06 Port2 7.80e-12
L07 N06 Port2 8.45e-11
R07 N06 Port2 2.55e+02
.ENDS GQM2195C2E6R8DB12

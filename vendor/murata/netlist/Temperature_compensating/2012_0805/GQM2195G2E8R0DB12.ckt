*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM2195G2E8R0DB12
* Property : C = 8.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.86e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.38e-12
R04 N03 N04 2.12e-02
C05 N04 N05 3.98e-12
L05 N04 N05 8.33e-11
C06 N05 N06 7.93e-12
L06 N05 N06 4.17e-11
R06 N05 N06 4.01e+01
C07 N06 Port2 1.43e-11
L07 N06 Port2 5.56e-11
R07 N06 Port2 1.39e+02
.ENDS GQM2195G2E8R0DB12

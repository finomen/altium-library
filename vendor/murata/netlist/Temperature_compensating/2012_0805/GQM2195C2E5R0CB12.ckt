*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM2195C2E5R0CB12
* Property : C = 5.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E5R0CB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-10
R03 N02 N03 4.00e-02
L04 N03 N04 5.05e-12
R04 N03 N04 1.90e-01
C05 N04 N05 3.01e-12
L05 N04 N05 9.52e-11
R05 N04 N05 4.50e+02
C06 N05 Port2 6.49e-12
L06 N05 Port2 7.43e-11
R06 N05 Port2 2.45e+02
.ENDS GQM2195C2E5R0CB12

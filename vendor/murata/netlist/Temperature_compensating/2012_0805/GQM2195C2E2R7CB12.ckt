*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.70e-06[uF]/250[V]
* Murata P/N :GQM2195C2E2R7CB12
* Property : C = 2.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E2R7CB12 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.53e-10
R03 N02 N03 7.00e-02
C04 N03 N04 3.44e-12
L04 N03 N04 9.61e-11
C05 N04 Port2 2.95e-11
L05 N04 Port2 1.19e-11
R05 N04 Port2 5.24e+00
.ENDS GQM2195C2E2R7CB12

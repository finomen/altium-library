*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM2195C2E9R1DB12
* Property : C = 9.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 3.49e-02
L04 N03 N04 1.43e-11
R04 N03 N04 2.94e-02
C05 N04 N05 1.54e-11
L05 N04 N05 5.93e-11
R05 N04 N05 1.35e+02
C06 N05 Port2 2.76e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.06e+02
.ENDS GQM2195C2E9R1DB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM2195G2E750FB12
* Property : C = 7.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E750FB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.25e-10
R03 N02 N03 2.98e-02
L04 N03 N04 5.59e-12
R04 N03 N04 1.64e-02
C05 N04 N05 1.46e-10
L05 N04 N05 4.66e-11
R05 N04 N05 2.14e+01
C06 N05 N06 7.48e-11
L06 N05 N06 3.48e-11
R06 N05 N06 2.58e+01
C07 N06 N07 1.33e-10
L07 N06 N07 9.42e-12
R07 N06 N07 1.09e+01
C08 N07 N08 4.83e-11
L08 N07 N08 1.60e-11
R08 N07 N08 2.50e+01
C09 N08 N09 3.99e-11
L09 N08 N09 1.28e-11
R09 N08 N09 2.84e+01
C10 N09 N10 4.07e-12
L10 N09 N10 9.58e-11
R10 N09 N10 2.28e+02
C11 N10 Port2 7.00e-12
L11 N10 Port2 4.87e-11
R11 N10 Port2 1.03e+02
.ENDS GQM2195G2E750FB12

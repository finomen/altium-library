*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.30e-04[uF]/250[V]
* Murata P/N :GQM2195C2E131JB12
* Property : C = 1.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E131JB12 Port1 Port2
C01 Port1 N01 1.30e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.91e-10
R03 N02 N03 2.80e-02
L04 N03 N04 6.02e-12
R04 N03 N04 1.46e-02
C05 N04 N05 2.69e-10
L05 N04 N05 4.28e-11
R05 N04 N05 1.49e+01
C06 N05 N06 1.33e-10
L06 N05 N06 3.28e-11
R06 N05 N06 1.38e+01
C07 N06 N07 2.01e-10
L07 N06 N07 1.04e-11
R07 N06 N07 6.51e+00
C08 N07 N08 9.40e-11
L08 N07 N08 1.35e-11
R08 N07 N08 1.02e+01
C09 N08 N09 1.52e-10
L09 N08 N09 5.45e-12
R09 N08 N09 5.20e+00
C10 N09 N10 9.97e-11
L10 N09 N10 6.01e-12
R10 N09 N10 9.46e+00
C11 N10 N11 2.01e-10
L11 N10 N11 2.22e-12
R11 N10 N11 4.30e+00
C12 N11 Port2 5.22e-11
L12 N11 Port2 6.50e-12
R12 N11 Port2 1.06e+01
.ENDS GQM2195C2E131JB12

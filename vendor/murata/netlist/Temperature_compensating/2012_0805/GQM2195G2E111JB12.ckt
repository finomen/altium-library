*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.10e-04[uF]/250[V]
* Murata P/N :GQM2195G2E111JB12
* Property : C = 1.10e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E111JB12 Port1 Port2
C01 Port1 N01 1.10e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 3.00e-02
L04 N03 N04 1.36e-11
R04 N03 N04 3.82e-01
C05 N04 N05 2.28e-10
L05 N04 N05 4.30e-11
R05 N04 N05 2.05e+01
C06 N05 N06 1.12e-10
L06 N05 N06 3.34e-11
R06 N05 N06 1.98e+01
C07 N06 N07 1.99e-10
L07 N06 N07 8.96e-12
R07 N06 N07 7.50e+00
C08 N07 N08 1.01e-10
L08 N07 N08 1.08e-11
R08 N07 N08 1.19e+01
C09 N08 N09 1.75e-10
L09 N08 N09 4.06e-12
R09 N08 N09 6.02e+00
C10 N09 N10 6.81e-11
L10 N09 N10 7.54e-12
R10 N09 N10 1.26e+01
C11 N10 Port2 1.41e-10
L11 N10 Port2 2.74e-12
R11 N10 Port2 8.74e+00
.ENDS GQM2195G2E111JB12

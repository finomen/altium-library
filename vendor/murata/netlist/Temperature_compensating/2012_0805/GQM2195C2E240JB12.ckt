*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM2195C2E240JB12
* Property : C = 2.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E240JB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.39e-11
R03 N02 N03 3.60e-02
L04 N03 N04 7.30e-12
R04 N03 N04 2.74e-02
C05 N04 N05 4.95e-11
L05 N04 N05 4.40e-11
R05 N04 N05 5.36e+01
C06 N05 N06 1.78e-11
L06 N05 N06 4.92e-11
R06 N05 N06 8.22e+01
C07 N06 N07 1.41e-11
L07 N06 N07 3.05e-11
R07 N06 N07 8.19e+01
C08 N07 N08 8.20e-12
L08 N07 N08 3.80e-11
R08 N07 N08 1.23e+02
C09 N08 Port2 1.17e-12
L09 N08 Port2 2.05e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E240JB12

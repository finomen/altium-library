*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM2195G2E270GB12
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E270GB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 3.50e-02
L04 N03 N04 4.22e-12
R04 N03 N04 2.65e-02
C05 N04 N05 6.85e-11
L05 N04 N05 3.66e-11
R05 N04 N05 3.63e+01
C06 N05 N06 1.94e-11
L06 N05 N06 5.16e-11
R06 N05 N06 9.60e+01
C07 N06 N07 2.84e-11
L07 N06 N07 1.71e-11
R07 N06 N07 4.28e+01
C08 N07 Port2 2.46e-12
L08 N07 Port2 1.22e-10
R08 N07 Port2 5.09e+02
.ENDS GQM2195G2E270GB12

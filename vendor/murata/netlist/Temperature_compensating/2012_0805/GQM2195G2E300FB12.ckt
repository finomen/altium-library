*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM2195G2E300FB12
* Property : C = 3.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E300FB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.77e-02
L04 N03 N04 7.92e-12
R04 N03 N04 2.25e-02
C05 N04 N05 6.98e-11
L05 N04 N05 3.85e-11
R05 N04 N05 4.41e+01
C06 N05 N06 2.93e-11
L06 N05 N06 3.62e-11
R06 N05 N06 5.81e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.69e-11
R07 N06 N07 4.27e+01
C08 N07 Port2 3.71e-12
L08 N07 Port2 9.34e-11
R08 N07 Port2 2.35e+02
.ENDS GQM2195G2E300FB12

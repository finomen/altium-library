*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM2195C2E360GB12
* Property : C = 3.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E360GB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 3.99e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.56e-02
C05 N04 N05 7.69e-11
L05 N04 N05 4.20e-11
R05 N04 N05 5.13e+01
C06 N05 N06 3.16e-11
L06 N05 N06 3.96e-11
R06 N05 N06 5.63e+01
C07 N06 N07 3.42e-11
L07 N06 N07 1.78e-11
R07 N06 N07 3.49e+01
C08 N07 N08 7.18e-12
L08 N07 N08 5.35e-11
R08 N07 N08 1.35e+02
C09 N08 Port2 2.43e-12
L09 N08 Port2 1.19e-10
R09 N08 Port2 1.00e+05
.ENDS GQM2195C2E360GB12

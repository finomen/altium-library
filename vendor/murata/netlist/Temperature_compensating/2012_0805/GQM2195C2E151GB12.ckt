*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.50e-04[uF]/250[V]
* Murata P/N :GQM2195C2E151GB12
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E151GB12 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.89e-10
R03 N02 N03 2.70e-02
L04 N03 N04 5.80e-12
R04 N03 N04 3.07e-02
C05 N04 N05 3.28e-10
L05 N04 N05 4.20e-11
R05 N04 N05 1.62e+01
C06 N05 N06 1.39e-10
L06 N05 N06 3.65e-11
R06 N05 N06 2.11e+01
C07 N06 N07 2.74e-10
L07 N06 N07 8.88e-12
R07 N06 N07 6.22e+00
C08 N07 N08 1.30e-10
L08 N07 N08 1.15e-11
R08 N07 N08 9.54e+00
C09 N08 N09 1.87e-10
L09 N08 N09 5.19e-12
R09 N08 N09 4.42e+00
C10 N09 N10 1.05e-10
L10 N09 N10 6.57e-12
R10 N09 N10 8.39e+00
C11 N10 N11 1.50e-10
L11 N10 N11 3.44e-12
R11 N10 N11 4.86e+00
C12 N11 Port2 6.78e-11
L12 N11 Port2 5.93e-12
R12 N11 Port2 1.08e+01
.ENDS GQM2195C2E151GB12

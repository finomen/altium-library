*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM2195G2E130GB12
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.94e-11
R03 N02 N03 3.74e-02
L04 N03 N04 8.51e-12
R04 N03 N04 2.85e-02
C05 N04 N05 2.15e-11
L05 N04 N05 5.50e-11
R05 N04 N05 9.62e+01
C06 N05 N06 6.04e-12
L06 N05 N06 8.18e-11
R06 N05 N06 2.38e+02
C07 N06 N07 3.13e-12
L07 N06 N07 8.92e-11
R07 N06 N07 2.54e+02
C08 N07 Port2 2.91e-12
L08 N07 Port2 7.05e-11
R08 N07 Port2 1.00e+05
.ENDS GQM2195G2E130GB12

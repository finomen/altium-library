*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/X8G(-55to150[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM2195G2H1R0CB12
* Property : C = 1.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195G2H1R0CB12 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 2.00e-01
L04 N03 N04 3.17e-12
R04 N03 N04 7.91e-01
C05 N04 Port2 4.07e-12
L05 N04 Port2 4.80e-11
R05 N04 Port2 9.00e+02
.ENDS GQM2195G2H1R0CB12

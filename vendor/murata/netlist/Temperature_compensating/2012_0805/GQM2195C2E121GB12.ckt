*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2012M(0805)/C0G(-55to125[deg])/1.20e-04[uF]/250[V]
* Murata P/N :GQM2195C2E121GB12
* Property : C = 1.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM2195C2E121GB12 Port1 Port2
C01 Port1 N01 1.20e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.95e-10
R03 N02 N03 2.90e-02
L04 N03 N04 4.19e-12
R04 N03 N04 4.44e-02
C05 N04 N05 2.55e-10
L05 N04 N05 4.21e-11
R05 N04 N05 1.76e+01
C06 N05 N06 1.36e-10
L06 N05 N06 3.00e-11
R06 N05 N06 1.68e+01
C07 N06 N07 2.20e-10
L07 N06 N07 8.91e-12
R07 N06 N07 6.66e+00
C08 N07 N08 1.00e-10
L08 N07 N08 1.18e-11
R08 N07 N08 9.60e+00
C09 N08 N09 1.45e-10
L09 N08 N09 5.36e-12
R09 N08 N09 5.51e+00
C10 N09 N10 8.11e-11
L10 N09 N10 6.86e-12
R10 N09 N10 9.23e+00
C11 N10 Port2 1.12e-10
L11 N10 Port2 3.71e-12
R11 N10 Port2 6.67e+00
.ENDS GQM2195C2E121GB12

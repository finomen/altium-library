*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.00e-07[uF]/100[V]
* Murata P/N :GJM0335C2AR60WB01
* Property : C = 6.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2AR60WB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-10
R03 N02 N03 2.91e-01
C04 N03 N04 3.35e-12
L04 N03 N04 6.29e-12
R04 N03 N04 1.49e+01
C05 N04 Port2 1.80e-12
L05 N04 Port2 5.73e-12
R05 N04 Port2 4.03e+01
.ENDS GJM0335C2AR60WB01

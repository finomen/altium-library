*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.10e-06[uF]/50[V]
* Murata P/N :GJM0335C1H2R1WB01
* Property : C = 2.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H2R1WB01 Port1 Port2
C01 Port1 N01 2.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.28e-11
L04 N03 N04 3.47e-12
R04 N03 N04 1.12e+01
C05 N04 N05 2.27e-12
L05 N04 N05 1.53e-11
R05 N04 N05 8.23e+01
C06 N05 N06 2.16e-11
L06 N05 N06 9.11e-13
R06 N05 N06 4.20e+00
C07 N06 N07 1.87e-11
L07 N06 N07 9.38e-13
R07 N06 N07 6.27e+00
C08 N07 Port2 6.35e-13
L08 N07 Port2 1.86e-11
R08 N07 Port2 1.72e+02
.ENDS GJM0335C1H2R1WB01

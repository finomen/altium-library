*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.30e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H6R3BB01
* Property : C = 6.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H6R3BB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 6.10e-02
L04 N03 N04 5.73e-12
R04 N03 N04 1.01e-01
C05 N04 N05 5.01e-11
L05 N04 N05 3.52e-12
R05 N04 N05 3.72e+00
C06 N05 N06 1.15e-11
L06 N05 N06 6.37e-12
R06 N05 N06 1.53e+01
C07 N06 N07 1.56e-10
L07 N06 N07 2.62e-13
R07 N06 N07 9.60e-01
C08 N07 N08 3.09e-11
L08 N07 N08 1.05e-12
R08 N07 N08 2.54e+00
C09 N08 N09 6.65e-12
L09 N08 N09 3.54e-12
R09 N08 N09 6.08e+00
C10 N09 N10 3.12e-11
L10 N09 N10 4.90e-13
R10 N09 N10 2.52e+00
C11 N10 Port2 2.51e-12
L11 N10 Port2 4.12e-12
R11 N10 Port2 2.96e+01
.ENDS GCQ0335C1H6R3BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.60e-05[uF]/200[V]
* Murata P/N :GQM0335C2D160GB01
* Property : C = 1.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D160GB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 3.60e-02
L04 N03 N04 8.90e-12
R04 N03 N04 7.71e-02
C05 N04 N05 1.36e-10
L05 N04 N05 2.93e-12
R05 N04 N05 2.31e+00
C06 N05 N06 2.24e-11
L06 N05 N06 6.58e-12
R06 N05 N06 6.62e+00
C07 N06 N07 1.70e-10
L07 N06 N07 4.52e-13
R07 N06 N07 5.50e-01
C08 N07 N08 4.07e-11
L08 N07 N08 1.36e-12
R08 N07 N08 1.62e+00
C09 N08 N09 8.91e-12
L09 N08 N09 3.44e-12
R09 N08 N09 5.02e+00
C10 N09 Port2 6.83e-12
L10 N09 Port2 2.94e-12
R10 N09 Port2 5.90e+00
.ENDS GQM0335C2D160GB01

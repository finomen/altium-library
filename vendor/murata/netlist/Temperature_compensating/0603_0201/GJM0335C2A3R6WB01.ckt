*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.60e-06[uF]/100[V]
* Murata P/N :GJM0335C2A3R6WB01
* Property : C = 3.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A3R6WB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.83e-10
R03 N02 N03 1.05e-01
L04 N03 N04 3.71e-12
R04 N03 N04 8.38e-02
C05 N04 N05 4.68e-11
L05 N04 N05 1.61e-12
R05 N04 N05 3.60e+00
C06 N05 N06 1.21e-11
L06 N05 N06 2.97e-12
R06 N05 N06 7.82e+00
C07 N06 N07 5.40e-12
L07 N06 N07 4.50e-12
R07 N06 N07 7.89e+00
C08 N07 N08 6.15e-12
L08 N07 N08 2.63e-12
R08 N07 N08 1.28e+01
C09 N08 Port2 2.95e-12
L09 N08 Port2 3.44e-12
R09 N08 Port2 2.07e+01
.ENDS GJM0335C2A3R6WB01

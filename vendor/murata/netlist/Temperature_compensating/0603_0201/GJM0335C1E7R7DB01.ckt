*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.70e-06[uF]/25[V]
* Murata P/N :GJM0335C1E7R7DB01
* Property : C = 7.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E7R7DB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 6.50e-12
R04 N03 N04 1.18e-01
C05 N04 N05 2.85e-10
L05 N04 N05 6.67e-13
R05 N04 N05 9.96e-01
C06 N05 N06 8.09e-12
L06 N05 N06 8.47e-12
R06 N05 N06 1.30e+01
C07 N06 N07 5.85e-12
L07 N06 N07 3.63e-12
R07 N06 N07 1.04e+01
C08 N07 N08 1.27e-12
L08 N07 N08 1.20e-11
R08 N07 N08 4.01e+01
C09 N08 Port2 1.10e-13
L09 N08 Port2 9.01e-11
R09 N08 Port2 8.94e+02
.ENDS GJM0335C1E7R7DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.40e-06[uF]/50[V]
* Murata P/N :GJM0335C1H4R4BB01
* Property : C = 4.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H4R4BB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 9.50e-02
L04 N03 N04 5.59e-12
R04 N03 N04 9.43e-02
C05 N04 N05 8.68e-11
L05 N04 N05 1.34e-12
R05 N04 N05 2.73e+00
C06 N05 N06 4.69e-12
L06 N05 N06 9.18e-12
R06 N05 N06 3.22e+01
C07 N06 N07 4.13e-12
L07 N06 N07 3.43e-12
R07 N06 N07 1.56e+01
C08 N07 Port2 2.90e-13
L08 N07 Port2 3.40e-11
R08 N07 Port2 2.07e+02
.ENDS GJM0335C1H4R4BB01

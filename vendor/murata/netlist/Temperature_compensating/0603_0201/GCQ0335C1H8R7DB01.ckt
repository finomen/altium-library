*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.70e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H8R7DB01
* Property : C = 8.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H8R7DB01 Port1 Port2
C01 Port1 N01 8.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 4.70e-02
L04 N03 N04 5.69e-12
R04 N03 N04 1.09e-01
C05 N04 N05 6.16e-11
L05 N04 N05 4.24e-12
R05 N04 N05 3.37e+00
C06 N05 N06 1.50e-11
L06 N05 N06 7.18e-12
R06 N05 N06 1.27e+01
C07 N06 N07 7.55e-11
L07 N06 N07 7.81e-13
R07 N06 N07 1.43e+00
C08 N07 N08 3.95e-11
L08 N07 N08 1.10e-12
R08 N07 N08 2.75e+00
C09 N08 N09 6.13e-12
L09 N08 N09 4.55e-12
R09 N08 N09 7.25e+00
C10 N09 N10 1.00e-11
L10 N09 N10 1.85e-12
R10 N09 N10 4.90e+00
C11 N10 Port2 6.26e-12
L11 N10 Port2 1.87e-12
R11 N10 Port2 1.03e+01
.ENDS GCQ0335C1H8R7DB01

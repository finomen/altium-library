*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/2.00e-05[uF]/100[V]
* Murata P/N :GJM0335G2A200JB01
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2A200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.20e-02
L04 N03 N04 1.00e-11
R04 N03 N04 7.09e-02
C05 N04 N05 2.04e-10
L05 N04 N05 2.77e-12
R05 N04 N05 2.14e+00
C06 N05 N06 2.80e-11
L06 N05 N06 7.87e-12
R06 N05 N06 6.42e+00
C07 N06 N07 1.23e-10
L07 N06 N07 9.05e-13
R07 N06 N07 8.66e-01
C08 N07 N08 3.00e-11
L08 N07 N08 2.47e-12
R08 N07 N08 2.76e+00
C09 N08 N09 7.31e-12
L09 N08 N09 2.28e-12
R09 N08 N09 5.25e+00
C10 N09 Port2 2.77e-12
L10 N09 Port2 3.63e-12
R10 N09 Port2 1.29e+01
.ENDS GJM0335G2A200JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.60e-06[uF]/25[V]
* Murata P/N :GJM0335C1E4R6BB01
* Property : C = 4.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E4R6BB01 Port1 Port2
C01 Port1 N01 4.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.81e-12
R04 N03 N04 1.24e-01
C05 N04 N05 1.14e-10
L05 N04 N05 1.18e-12
R05 N04 N05 3.30e+00
C06 N05 N06 6.17e-12
L06 N05 N06 8.17e-12
R06 N05 N06 2.45e+01
C07 N06 N07 3.66e-12
L07 N06 N07 4.55e-12
R07 N06 N07 2.96e+01
C08 N07 Port2 1.52e-13
L08 N07 Port2 6.14e-11
R08 N07 Port2 6.69e+02
.ENDS GJM0335C1E4R6BB01

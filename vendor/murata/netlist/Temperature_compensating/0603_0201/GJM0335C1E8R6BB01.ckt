*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.60e-06[uF]/25[V]
* Murata P/N :GJM0335C1E8R6BB01
* Property : C = 8.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E8R6BB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 9.50e-02
L04 N03 N04 5.99e-12
R04 N03 N04 1.02e-01
C05 N04 N05 2.10e-10
L05 N04 N05 1.13e-12
R05 N04 N05 1.11e+00
C06 N05 N06 1.01e-11
L06 N05 N06 8.80e-12
R06 N05 N06 1.15e+01
C07 N06 N07 1.48e-12
L07 N06 N07 1.84e-11
R07 N06 N07 3.64e+01
C08 N07 Port2 2.13e-13
L08 N07 Port2 5.53e-11
R08 N07 Port2 5.43e+02
.ENDS GJM0335C1E8R6BB01

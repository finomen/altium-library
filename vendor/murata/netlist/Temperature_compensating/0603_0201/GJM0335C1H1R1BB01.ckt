*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.10e-06[uF]/50[V]
* Murata P/N :GJM0335C1H1R1BB01
* Property : C = 1.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.44e-10
R03 N02 N03 2.94e-01
C04 N03 N04 1.22e-10
L04 N03 N04 2.80e-13
R04 N03 N04 9.49e-01
C05 N04 N05 3.38e-11
L05 N04 N05 8.39e-13
R05 N04 N05 3.87e+00
C06 N05 Port2 1.01e-12
L06 N05 Port2 1.10e-11
R06 N05 Port2 1.70e+02
.ENDS GJM0335C1H1R1BB01

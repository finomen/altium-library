*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.60e-06[uF]/200[V]
* Murata P/N :GQM0335C2D2R6WB01
* Property : C = 2.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D2R6WB01 Port1 Port2
C01 Port1 N01 2.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-10
R03 N02 N03 1.38e-01
L04 N03 N04 2.39e-12
R04 N03 N04 6.63e-02
C05 N04 N05 2.49e-11
L05 N04 N05 2.64e-12
R05 N04 N05 7.74e+00
C06 N05 N06 7.33e-12
L06 N05 N06 4.44e-12
R06 N05 N06 1.14e+01
C07 N06 N07 7.13e-12
L07 N06 N07 3.57e-12
R07 N06 N07 6.45e+00
C08 N07 N08 3.66e-12
L08 N07 N08 4.54e-12
R08 N07 N08 1.88e+01
C09 N08 Port2 2.18e-12
L09 N08 Port2 4.84e-12
R09 N08 Port2 3.44e+01
.ENDS GQM0335C2D2R6WB01

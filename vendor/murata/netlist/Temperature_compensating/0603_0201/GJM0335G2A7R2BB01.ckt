*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/7.20e-06[uF]/100[V]
* Murata P/N :GJM0335G2A7R2BB01
* Property : C = 7.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2A7R2BB01 Port1 Port2
C01 Port1 N01 7.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 5.30e-02
L04 N03 N04 6.08e-12
R04 N03 N04 9.30e-02
C05 N04 N05 5.60e-11
L05 N04 N05 3.65e-12
R05 N04 N05 3.01e+00
C06 N05 N06 1.11e-11
L06 N05 N06 7.58e-12
R06 N05 N06 1.38e+01
C07 N06 N07 6.48e-11
L07 N06 N07 7.09e-13
R07 N06 N07 1.42e+00
C08 N07 N08 1.92e-11
L08 N07 N08 1.89e-12
R08 N07 N08 3.86e+00
C09 N08 N09 4.66e-12
L09 N08 N09 4.34e-12
R09 N08 N09 8.69e+00
C10 N09 N10 2.12e-11
L10 N09 N10 7.55e-13
R10 N09 N10 3.88e+00
C11 N10 Port2 6.50e-13
L11 N10 Port2 1.42e-11
R11 N10 Port2 1.72e+02
.ENDS GJM0335G2A7R2BB01

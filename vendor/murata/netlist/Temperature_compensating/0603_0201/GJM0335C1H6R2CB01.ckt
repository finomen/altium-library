*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.20e-06[uF]/50[V]
* Murata P/N :GJM0335C1H6R2CB01
* Property : C = 6.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 1.05e-01
L04 N03 N04 3.64e-12
R04 N03 N04 8.57e-02
C05 N04 N05 7.08e-11
L05 N04 N05 2.79e-12
R05 N04 N05 2.92e+00
C06 N05 N06 8.95e-12
L06 N05 N06 8.61e-12
R06 N05 N06 2.08e+01
C07 N06 N07 8.73e-11
L07 N06 N07 4.38e-13
R07 N06 N07 1.08e+00
C08 N07 N08 1.14e-11
L08 N07 N08 2.13e-12
R08 N07 N08 1.03e+01
C09 N08 N09 6.91e-11
L09 N08 N09 2.51e-13
R09 N08 N09 8.57e-01
C10 N09 N10 1.16e-11
L10 N09 N10 1.15e-12
R10 N09 N10 7.11e+00
C11 N10 Port2 7.68e-13
L11 N10 Port2 1.17e-11
R11 N10 Port2 6.14e+01
.ENDS GJM0335C1H6R2CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GJM0335C1E180JB01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 6.90e-02
L04 N03 N04 8.05e-12
R04 N03 N04 6.54e-02
C05 N04 N05 2.30e-10
L05 N04 N05 3.09e-12
R05 N04 N05 1.93e+00
C06 N05 N06 3.41e-11
L06 N05 N06 8.53e-12
R06 N05 N06 6.93e+00
C07 N06 N07 2.14e-10
L07 N06 N07 6.81e-13
R07 N06 N07 5.98e-01
C08 N07 N08 3.56e-11
L08 N07 N08 2.61e-12
R08 N07 N08 3.21e+00
C09 N08 N09 6.19e-10
L09 N08 N09 1.50e-13
R09 N08 N09 2.07e-01
C10 N09 N10 3.25e-11
L10 N09 N10 1.43e-12
R10 N09 N10 2.67e+00
C11 N10 N11 1.88e-11
L11 N10 N11 1.53e-12
R11 N10 N11 3.07e+00
C12 N11 Port2 1.03e-12
L12 N11 Port2 1.02e-11
R12 N11 Port2 9.05e+01
.ENDS GJM0335C1E180JB01

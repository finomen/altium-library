*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.90e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H7R9BB01
* Property : C = 7.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H7R9BB01 Port1 Port2
C01 Port1 N01 7.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 5.10e-02
L04 N03 N04 6.91e-12
R04 N03 N04 8.70e-02
C05 N04 N05 6.33e-11
L05 N04 N05 3.38e-12
R05 N04 N05 2.71e+00
C06 N05 N06 1.07e-11
L06 N05 N06 8.28e-12
R06 N05 N06 1.37e+01
C07 N06 N07 6.32e-11
L07 N06 N07 7.99e-13
R07 N06 N07 1.90e+00
C08 N07 N08 1.34e-11
L08 N07 N08 2.81e-12
R08 N07 N08 4.11e+00
C09 N08 N09 7.05e-12
L09 N08 N09 2.33e-12
R09 N08 N09 8.89e+00
C10 N09 Port2 3.86e-12
L10 N09 Port2 3.29e-12
R10 N09 Port2 1.33e+01
.ENDS GCQ0335C1H7R9BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.30e-06[uF]/25[V]
* Murata P/N :GJM0335C1E8R3CB01
* Property : C = 8.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E8R3CB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.97e-10
R03 N02 N03 1.00e-01
L04 N03 N04 6.06e-12
R04 N03 N04 1.27e-01
C05 N04 N05 2.14e-10
L05 N04 N05 1.00e-12
R05 N04 N05 1.02e+00
C06 N05 N06 1.12e-11
L06 N05 N06 7.00e-12
R06 N05 N06 1.21e+01
C07 N06 N07 2.14e-12
L07 N06 N07 1.09e-11
R07 N06 N07 2.07e+01
C08 N07 Port2 2.53e-13
L08 N07 Port2 4.04e-11
R08 N07 Port2 7.73e+02
.ENDS GJM0335C1E8R3CB01

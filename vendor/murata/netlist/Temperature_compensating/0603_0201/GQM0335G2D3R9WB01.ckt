*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/3.90e-06[uF]/200[V]
* Murata P/N :GQM0335G2D3R9WB01
* Property : C = 3.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D3R9WB01 Port1 Port2
C01 Port1 N01 3.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 9.90e-02
L04 N03 N04 3.88e-12
R04 N03 N04 6.87e-02
C05 N04 N05 3.24e-11
L05 N04 N05 2.97e-12
R05 N04 N05 5.38e+00
C06 N05 N06 7.31e-12
L06 N05 N06 5.68e-12
R06 N05 N06 1.50e+01
C07 N06 N07 4.31e-12
L07 N06 N07 5.38e-12
R07 N06 N07 9.64e+00
C08 N07 N08 1.36e-11
L08 N07 N08 1.31e-12
R08 N07 N08 3.99e+00
C09 N08 Port2 6.90e-13
L09 N08 Port2 1.57e-11
R09 N08 Port2 5.86e+01
.ENDS GQM0335G2D3R9WB01

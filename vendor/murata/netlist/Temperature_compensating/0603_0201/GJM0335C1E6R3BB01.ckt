*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.30e-06[uF]/25[V]
* Murata P/N :GJM0335C1E6R3BB01
* Property : C = 6.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E6R3BB01 Port1 Port2
C01 Port1 N01 6.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.05e-01
L04 N03 N04 4.15e-12
R04 N03 N04 5.50e-02
C05 N04 N05 7.68e-11
L05 N04 N05 2.67e-12
R05 N04 N05 2.79e+00
C06 N05 N06 9.13e-12
L06 N05 N06 8.71e-12
R06 N05 N06 1.90e+01
C07 N06 N07 8.43e-11
L07 N06 N07 4.75e-13
R07 N06 N07 1.42e+00
C08 N07 N08 1.12e-11
L08 N07 N08 2.25e-12
R08 N07 N08 1.27e+01
C09 N08 N09 4.12e-11
L09 N08 N09 4.15e-13
R09 N08 N09 1.72e+00
C10 N09 N10 9.41e-12
L10 N09 N10 1.46e-12
R10 N09 N10 9.55e+00
C11 N10 Port2 8.14e-13
L11 N10 Port2 1.17e-11
R11 N10 Port2 9.76e+01
.ENDS GJM0335C1E6R3BB01

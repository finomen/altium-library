*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H6R0WB01
* Property : C = 6.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H6R0WB01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 6.40e-02
L04 N03 N04 4.96e-12
R04 N03 N04 1.39e-01
C05 N04 N05 4.74e-11
L05 N04 N05 3.61e-12
R05 N04 N05 4.02e+00
C06 N05 N06 8.09e-12
L06 N05 N06 8.69e-12
R06 N05 N06 1.67e+01
C07 N06 N07 5.81e-11
L07 N06 N07 6.85e-13
R07 N06 N07 1.68e+00
C08 N07 N08 1.31e-11
L08 N07 N08 2.42e-12
R08 N07 N08 4.11e+00
C09 N08 N09 4.34e-12
L09 N08 N09 3.31e-12
R09 N08 N09 9.85e+00
C10 N09 Port2 3.17e-12
L10 N09 Port2 3.20e-12
R10 N09 Port2 1.90e+01
.ENDS GCQ0335C1H6R0WB01

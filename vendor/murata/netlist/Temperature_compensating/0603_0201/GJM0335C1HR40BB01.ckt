*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GJM0335C1HR40BB01
* Property : C = 4.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1HR40BB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 4.34e-01
C04 N03 Port2 1.44e-12
L04 N03 Port2 1.28e-11
R04 N03 Port2 5.40e+01
.ENDS GJM0335C1HR40BB01

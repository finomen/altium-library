*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.30e-06[uF]/200[V]
* Murata P/N :GQM0335C2D9R3WB01
* Property : C = 9.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D9R3WB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 4.50e-02
L04 N03 N04 5.90e-12
R04 N03 N04 9.89e-02
C05 N04 N05 4.21e-11
L05 N04 N05 6.61e-12
R05 N04 N05 6.64e+00
C06 N05 N06 1.51e-11
L06 N05 N06 7.50e-12
R06 N05 N06 1.19e+01
C07 N06 N07 7.69e-11
L07 N06 N07 7.94e-13
R07 N06 N07 1.61e+00
C08 N07 N08 3.17e-11
L08 N07 N08 1.41e-12
R08 N07 N08 3.28e+00
C09 N08 N09 6.46e-12
L09 N08 N09 4.42e-12
R09 N08 N09 7.18e+00
C10 N09 N10 1.15e-11
L10 N09 N10 1.06e-12
R10 N09 N10 6.73e+00
C11 N10 Port2 5.56e-12
L11 N10 Port2 1.84e-12
R11 N10 Port2 1.55e+01
.ENDS GQM0335C2D9R3WB01

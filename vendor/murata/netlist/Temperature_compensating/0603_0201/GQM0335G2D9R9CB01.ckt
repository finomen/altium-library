*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/9.90e-06[uF]/200[V]
* Murata P/N :GQM0335G2D9R9CB01
* Property : C = 9.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D9R9CB01 Port1 Port2
C01 Port1 N01 9.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 5.33e-02
L04 N03 N04 4.84e-12
R04 N03 N04 1.12e-01
C05 N04 N05 8.57e-11
L05 N04 N05 3.20e-12
R05 N04 N05 3.27e+00
C06 N05 N06 1.59e-11
L06 N05 N06 6.86e-12
R06 N05 N06 1.00e+01
C07 N06 N07 1.03e-10
L07 N06 N07 5.68e-13
R07 N06 N07 8.44e-01
C08 N07 N08 3.18e-11
L08 N07 N08 1.31e-12
R08 N07 N08 2.64e+00
C09 N08 N09 6.90e-12
L09 N08 N09 3.78e-12
R09 N08 N09 7.22e+00
C10 N09 Port2 1.75e-12
L10 N09 Port2 5.52e-12
R10 N09 Port2 6.47e+00
.ENDS GQM0335G2D9R9CB01

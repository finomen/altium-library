*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.10e-06[uF]/50[V]
* Murata P/N :GJM0335C1H4R1CB01
* Property : C = 4.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H4R1CB01 Port1 Port2
C01 Port1 N01 4.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 1.02e-01
L04 N03 N04 5.12e-12
R04 N03 N04 1.02e-01
C05 N04 N05 6.39e-11
L05 N04 N05 1.64e-12
R05 N04 N05 2.53e+00
C06 N05 N06 4.01e-12
L06 N05 N06 9.52e-12
R06 N05 N06 2.92e+01
C07 N06 N07 3.25e-12
L07 N06 N07 3.75e-12
R07 N06 N07 3.28e+01
C08 N07 Port2 7.43e-13
L08 N07 Port2 1.35e-11
R08 N07 Port2 1.34e+02
.ENDS GJM0335C1H4R1CB01

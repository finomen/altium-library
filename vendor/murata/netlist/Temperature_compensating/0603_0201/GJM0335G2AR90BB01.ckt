*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/9.00e-07[uF]/100[V]
* Murata P/N :GJM0335G2AR90BB01
* Property : C = 9.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2AR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 2.56e-01
C04 N03 N04 9.30e-12
L04 N03 N04 2.48e-12
R04 N03 N04 8.37e+00
C05 N04 N05 6.07e-12
L05 N04 N05 3.31e-12
R05 N04 N05 9.19e+00
C06 N05 N06 5.86e-12
L06 N05 N06 2.20e-12
R06 N05 N06 1.63e+01
C07 N06 Port2 1.40e-12
L07 N06 Port2 7.14e-12
R07 N06 Port2 2.70e+01
.ENDS GJM0335G2AR90BB01

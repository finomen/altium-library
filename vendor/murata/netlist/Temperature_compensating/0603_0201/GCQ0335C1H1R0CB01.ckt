*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H1R0CB01
* Property : C = 1.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 2.53e-01
C04 N03 N04 1.43e-11
L04 N03 N04 1.85e-12
R04 N03 N04 3.86e+00
C05 N04 N05 6.44e-12
L05 N04 N05 3.07e-12
R05 N04 N05 6.29e+00
C06 N05 N06 4.38e-12
L06 N05 N06 2.85e-12
R06 N05 N06 2.18e+01
C07 N06 Port2 1.04e-12
L07 N06 Port2 9.92e-12
R07 N06 Port2 6.86e+01
.ENDS GCQ0335C1H1R0CB01

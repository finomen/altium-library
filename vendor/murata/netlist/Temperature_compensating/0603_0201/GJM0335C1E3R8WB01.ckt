*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.80e-06[uF]/25[V]
* Murata P/N :GJM0335C1E3R8WB01
* Property : C = 3.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E3R8WB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 1.04e-01
L04 N03 N04 4.86e-12
R04 N03 N04 9.84e-02
C05 N04 N05 1.19e-10
L05 N04 N05 8.93e-13
R05 N04 N05 2.02e+00
C06 N05 N06 4.52e-12
L06 N05 N06 8.72e-12
R06 N05 N06 3.50e+01
C07 N06 N07 2.22e-12
L07 N06 N07 6.01e-12
R07 N06 N07 4.40e+01
C08 N07 Port2 1.80e-13
L08 N07 Port2 5.38e-11
R08 N07 Port2 4.76e+02
.ENDS GJM0335C1E3R8WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/1.20e-06[uF]/200[V]
* Murata P/N :GQM0335G2D1R2CB01
* Property : C = 1.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D1R2CB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.65e-10
R03 N02 N03 2.31e-01
C04 N03 N04 9.22e-12
L04 N03 N04 3.04e-12
R04 N03 N04 5.78e+00
C05 N04 N05 6.21e-12
L05 N04 N05 3.24e-12
R05 N04 N05 9.74e+00
C06 N05 N06 2.03e-12
L06 N05 N06 6.11e-12
R06 N05 N06 5.06e+01
C07 N06 Port2 2.80e-13
L07 N06 Port2 3.83e-11
R07 N06 Port2 2.91e+02
.ENDS GQM0335G2D1R2CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/4.70e-06[uF]/200[V]
* Murata P/N :GQM0335G2D4R7CB01
* Property : C = 4.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 8.40e-02
L04 N03 N04 4.58e-12
R04 N03 N04 1.01e-01
C05 N04 N05 3.38e-11
L05 N04 N05 3.28e-12
R05 N04 N05 6.19e+00
C06 N05 N06 7.19e-12
L06 N05 N06 6.52e-12
R06 N05 N06 1.38e+01
C07 N06 N07 4.82e-12
L07 N06 N07 4.07e-12
R07 N06 N07 5.59e+00
C08 N07 Port2 1.66e-12
L08 N07 Port2 6.25e-12
R08 N07 Port2 2.25e+01
.ENDS GQM0335G2D4R7CB01

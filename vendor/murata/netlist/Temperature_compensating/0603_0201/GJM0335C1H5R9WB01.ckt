*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.90e-06[uF]/50[V]
* Murata P/N :GJM0335C1H5R9WB01
* Property : C = 5.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H5R9WB01 Port1 Port2
C01 Port1 N01 5.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.18e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.70e-12
R04 N03 N04 8.96e-02
C05 N04 N05 1.38e-10
L05 N04 N05 1.37e-12
R05 N04 N05 1.60e+00
C06 N05 N06 8.71e-12
L06 N05 N06 8.54e-12
R06 N05 N06 2.08e+01
C07 N06 N07 9.39e-11
L07 N06 N07 3.90e-13
R07 N06 N07 1.30e+00
C08 N07 N08 6.63e-12
L08 N07 N08 3.50e-12
R08 N07 N08 1.44e+01
C09 N08 N09 5.88e-12
L09 N08 N09 2.10e-12
R09 N08 N09 1.50e+01
C10 N09 Port2 1.94e-12
L10 N09 Port2 5.25e-12
R10 N09 Port2 4.15e+01
.ENDS GJM0335C1H5R9WB01

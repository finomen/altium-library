*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GJM0335C1E120GB01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.76e-10
R03 N02 N03 8.10e-02
L04 N03 N04 7.74e-12
R04 N03 N04 7.77e-02
C05 N04 N05 2.29e-10
L05 N04 N05 1.73e-12
R05 N04 N05 1.36e+00
C06 N05 N06 1.81e-11
L06 N05 N06 8.48e-12
R06 N05 N06 9.05e+00
C07 N06 N07 1.58e-11
L07 N06 N07 3.02e-12
R07 N06 N07 5.33e+00
C08 N07 N08 1.11e-11
L08 N07 N08 2.15e-12
R08 N07 N08 5.21e+00
C09 N08 N09 1.53e-11
L09 N08 N09 1.29e-12
R09 N08 N09 4.13e+00
C10 N09 N10 7.82e-12
L10 N09 N10 1.99e-12
R10 N09 N10 7.88e+00
C11 N10 Port2 2.64e-13
L11 N10 Port2 3.94e-11
R11 N10 Port2 2.73e+02
.ENDS GJM0335C1E120GB01

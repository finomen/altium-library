*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.30e-06[uF]/25[V]
* Murata P/N :GJM0335C1E9R3BB01
* Property : C = 9.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E9R3BB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 9.50e-02
L04 N03 N04 6.15e-12
R04 N03 N04 1.21e-01
C05 N04 N05 2.57e-10
L05 N04 N05 1.02e-12
R05 N04 N05 1.15e+00
C06 N05 N06 1.24e-11
L06 N05 N06 7.80e-12
R06 N05 N06 9.71e+00
C07 N06 N07 6.08e-12
L07 N06 N07 4.86e-12
R07 N06 N07 8.57e+00
C08 N07 N08 4.78e-12
L08 N07 N08 4.37e-12
R08 N07 N08 1.10e+01
C09 N08 N09 1.22e-11
L09 N08 N09 1.33e-12
R09 N08 N09 5.34e+00
C10 N09 Port2 1.07e-12
L10 N09 Port2 9.69e-12
R10 N09 Port2 6.08e+01
.ENDS GJM0335C1E9R3BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-07[uF]/100[V]
* Murata P/N :GJM0335C2AR20WB01
* Property : C = 2.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2AR20WB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.21e-10
R03 N02 N03 4.07e-01
C04 N03 N04 2.28e-11
L04 N03 N04 9.06e-13
R04 N03 N04 1.96e+00
C05 N04 Port2 7.70e-13
L05 N04 Port2 1.32e-11
R05 N04 Port2 6.95e+01
.ENDS GJM0335C2AR20WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-06[uF]/50[V]
* Murata P/N :GJM0335C1H5R0WB01
* Property : C = 5.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H5R0WB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.13e-10
R03 N02 N03 9.50e-02
L04 N03 N04 5.51e-12
R04 N03 N04 1.07e-01
C05 N04 N05 1.43e-10
L05 N04 N05 9.46e-13
R05 N04 N05 2.35e+00
C06 N05 N06 6.77e-12
L06 N05 N06 7.54e-12
R06 N05 N06 2.29e+01
C07 N06 N07 4.99e-11
L07 N06 N07 4.98e-13
R07 N06 N07 1.91e+00
C08 N07 N08 5.70e-12
L08 N07 N08 2.83e-12
R08 N07 N08 1.92e+01
C09 N08 Port2 8.51e-13
L09 N08 Port2 1.17e-11
R09 N08 Port2 1.15e+02
.ENDS GJM0335C1H5R0WB01

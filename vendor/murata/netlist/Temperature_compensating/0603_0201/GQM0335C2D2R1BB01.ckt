*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.10e-06[uF]/200[V]
* Murata P/N :GQM0335C2D2R1BB01
* Property : C = 2.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D2R1BB01 Port1 Port2
C01 Port1 N01 2.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 1.88e-01
C04 N03 N04 4.25e-11
L04 N03 N04 1.21e-12
R04 N03 N04 4.08e+00
C05 N04 N05 1.20e-11
L05 N04 N05 2.31e-12
R05 N04 N05 6.79e+00
C06 N05 N06 3.95e-12
L06 N05 N06 4.98e-12
R06 N05 N06 7.52e+00
C07 N06 N07 4.92e-12
L07 N06 N07 2.88e-12
R07 N06 N07 1.96e+01
C08 N07 Port2 3.17e-12
L08 N07 Port2 3.39e-12
R08 N07 Port2 2.84e+01
.ENDS GQM0335C2D2R1BB01

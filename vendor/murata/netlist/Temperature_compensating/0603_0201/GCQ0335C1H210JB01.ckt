*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.10e-05[uF]/50[V]
* Murata P/N :GCQ0335C1H210JB01
* Property : C = 2.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H210JB01 Port1 Port2
C01 Port1 N01 2.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 3.20e-02
L04 N03 N04 1.37e-11
R04 N03 N04 6.23e-02
C05 N04 N05 1.32e-10
L05 N04 N05 4.78e-12
R05 N04 N05 2.92e+00
C06 N05 N06 3.54e-11
L06 N05 N06 7.13e-12
R06 N05 N06 5.76e+00
C07 N06 N07 1.66e-10
L07 N06 N07 7.71e-13
R07 N06 N07 8.24e-01
C08 N07 N08 4.14e-11
L08 N07 N08 2.02e-12
R08 N07 N08 2.42e+00
C09 N08 N09 1.45e-11
L09 N08 N09 1.99e-12
R09 N08 N09 3.73e+00
C10 N09 N10 8.26e-12
L10 N09 N10 2.37e-12
R10 N09 N10 2.81e+00
C11 N10 Port2 9.91e-12
L11 N10 Port2 1.02e-12
R11 N10 Port2 8.76e+00
.ENDS GCQ0335C1H210JB01

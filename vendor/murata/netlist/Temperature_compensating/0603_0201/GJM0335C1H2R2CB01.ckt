*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GJM0335C1H2R2CB01
* Property : C = 2.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H2R2CB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 1.76e-01
C04 N03 N04 3.15e-11
L04 N03 N04 2.59e-12
R04 N03 N04 9.27e+00
C05 N04 N05 2.88e-12
L05 N04 N05 1.25e-11
R05 N04 N05 6.39e+01
C06 N05 N06 1.60e-11
L06 N05 N06 1.18e-12
R06 N05 N06 9.36e+00
C07 N06 Port2 1.75e-12
L07 N06 Port2 7.11e-12
R07 N06 Port2 8.13e+01
.ENDS GJM0335C1H2R2CB01

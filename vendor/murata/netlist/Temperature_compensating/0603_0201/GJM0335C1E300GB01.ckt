*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.00e-05[uF]/25[V]
* Murata P/N :GJM0335C1E300GB01
* Property : C = 3.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E300GB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 6.40e-02
L04 N03 N04 7.95e-12
R04 N03 N04 1.20e-01
C05 N04 N05 2.85e-10
L05 N04 N05 3.95e-12
R05 N04 N05 1.70e+00
C06 N05 Port2 4.54e-11
L06 N05 Port2 1.01e-11
R06 N05 Port2 5.11e+00
.ENDS GJM0335C1E300GB01

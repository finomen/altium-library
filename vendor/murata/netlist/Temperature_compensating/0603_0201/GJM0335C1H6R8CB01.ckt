*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GJM0335C1H6R8CB01
* Property : C = 6.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.14e-10
R03 N02 N03 1.02e-01
L04 N03 N04 3.68e-12
R04 N03 N04 5.81e-02
C05 N04 N05 7.26e-11
L05 N04 N05 3.35e-12
R05 N04 N05 3.49e+00
C06 N05 N06 1.07e-11
L06 N05 N06 9.10e-12
R06 N05 N06 2.11e+01
C07 N06 N07 1.33e-11
L07 N06 N07 2.35e-12
R07 N06 N07 7.92e+00
C08 N07 N08 1.12e-11
L08 N07 N08 1.46e-12
R08 N07 N08 7.54e+00
C09 N08 Port2 7.48e-12
L09 N08 Port2 1.45e-12
R09 N08 Port2 6.27e+00
.ENDS GJM0335C1H6R8CB01

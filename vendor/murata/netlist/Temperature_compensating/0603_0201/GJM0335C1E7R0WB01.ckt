*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.00e-06[uF]/25[V]
* Murata P/N :GJM0335C1E7R0WB01
* Property : C = 7.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E7R0WB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.02e-01
L04 N03 N04 7.71e-12
R04 N03 N04 1.22e-01
C05 N04 N05 1.33e-10
L05 N04 N05 1.23e-12
R05 N04 N05 8.73e-01
C06 N05 N06 7.35e-12
L06 N05 N06 8.14e-12
R06 N05 N06 1.23e+01
C07 N06 N07 3.21e-12
L07 N06 N07 5.97e-12
R07 N06 N07 1.68e+01
C08 N07 Port2 7.16e-13
L08 N07 Port2 1.38e-11
R08 N07 Port2 7.61e+01
.ENDS GJM0335C1E7R0WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.60e-06[uF]/100[V]
* Murata P/N :GJM0335C2A9R6DB01
* Property : C = 9.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A9R6DB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 4.40e-02
L04 N03 N04 7.64e-12
R04 N03 N04 8.28e-02
C05 N04 N05 8.27e-11
L05 N04 N05 3.19e-12
R05 N04 N05 3.96e+00
C06 N05 N06 1.25e-11
L06 N05 N06 8.44e-12
R06 N05 N06 1.12e+01
C07 N06 N07 9.01e-11
L07 N06 N07 6.47e-13
R07 N06 N07 1.11e+00
C08 N07 N08 4.92e-11
L08 N07 N08 8.29e-13
R08 N07 N08 2.15e+00
C09 N08 N09 4.01e-12
L09 N08 N09 3.96e-12
R09 N08 N09 1.09e+01
C10 N09 Port2 1.23e-12
L10 N09 Port2 7.71e-12
R10 N09 Port2 3.56e+01
.ENDS GJM0335C2A9R6DB01

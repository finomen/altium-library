*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.40e-06[uF]/50[V]
* Murata P/N :GJM0335C1H1R4CB01
* Property : C = 1.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H1R4CB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 2.55e-01
L04 N03 N04 8.20e-13
R04 N03 N04 3.73e-02
C05 N04 N05 9.88e-10
L05 N04 N05 6.43e-14
R05 N04 N05 2.32e-01
C06 N05 N06 4.65e-10
L06 N05 N06 1.22e-13
R06 N05 N06 3.31e-01
C07 N06 N07 1.86e-11
L07 N06 N07 2.31e-12
R07 N06 N07 7.84e+00
C08 N07 N08 1.64e-12
L08 N07 N08 1.12e-11
R08 N07 N08 1.19e+02
C09 N08 Port2 1.99e-12
L09 N08 Port2 5.02e-12
R09 N08 Port2 2.07e+01
.ENDS GJM0335C1H1R4CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/6.3[V]
* Murata P/N :GJM0335C0J220JB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C0J220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.06e-10
R03 N02 N03 6.00e-02
L04 N03 N04 8.72e-12
R04 N03 N04 8.34e-02
C05 N04 N05 2.68e-10
L05 N04 N05 2.95e-12
R05 N04 N05 1.39e+00
C06 N05 N06 3.96e-11
L06 N05 N06 8.31e-12
R06 N05 N06 5.05e+00
C07 N06 N07 4.26e-11
L07 N06 N07 2.38e-12
R07 N06 N07 2.19e+00
C08 N07 N08 3.30e-11
L08 N07 N08 1.53e-12
R08 N07 N08 1.46e+00
C09 N08 Port2 7.73e-13
L09 N08 Port2 1.42e-11
R09 N08 Port2 8.59e+01
.ENDS GJM0335C0J220JB01

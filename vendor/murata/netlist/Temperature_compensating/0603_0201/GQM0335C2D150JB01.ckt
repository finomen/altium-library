*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/200[V]
* Murata P/N :GQM0335C2D150JB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 3.80e-02
L04 N03 N04 8.49e-12
R04 N03 N04 7.13e-02
C05 N04 N05 1.08e-10
L05 N04 N05 3.94e-12
R05 N04 N05 3.66e+00
C06 N05 N06 2.38e-11
L06 N05 N06 7.04e-12
R06 N05 N06 7.89e+00
C07 N06 N07 1.08e-10
L07 N06 N07 7.90e-13
R07 N06 N07 9.93e-01
C08 N07 N08 3.84e-11
L08 N07 N08 1.54e-12
R08 N07 N08 2.44e+00
C09 N08 N09 9.81e-12
L09 N08 N09 3.80e-12
R09 N08 N09 4.54e+00
C10 N09 Port2 4.45e-12
L10 N09 Port2 4.56e-12
R10 N09 Port2 5.46e+00
.ENDS GQM0335C2D150JB01

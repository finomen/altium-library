*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-05[uF]/25[V]
* Murata P/N :GJM0335C1E200GB01
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 6.70e-02
L04 N03 N04 9.05e-12
R04 N03 N04 5.83e-02
C05 N04 N05 2.52e-10
L05 N04 N05 3.13e-12
R05 N04 N05 1.84e+00
C06 N05 N06 3.50e-11
L06 N05 N06 9.36e-12
R06 N05 N06 6.68e+00
C07 N06 N07 3.08e-10
L07 N06 N07 5.39e-13
R07 N06 N07 5.10e-01
C08 N07 N08 3.62e-11
L08 N07 N08 2.89e-12
R08 N07 N08 3.45e+00
C09 N08 N09 3.56e-11
L09 N08 N09 1.48e-12
R09 N08 N09 2.28e+00
C10 N09 N10 4.57e-12
L10 N09 N10 4.49e-12
R10 N09 N10 6.42e+00
C11 N10 Port2 7.55e-13
L11 N10 Port2 1.31e-11
R11 N10 Port2 7.55e+01
.ENDS GJM0335C1E200GB01

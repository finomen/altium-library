*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-07[uF]/50[V]
* Murata P/N :GCQ0335C1HR80WB01
* Property : C = 8.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1HR80WB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.91e-10
R03 N02 N03 2.59e-01
C04 N03 N04 4.07e-12
L04 N03 N04 5.10e-12
R04 N03 N04 1.19e+01
C05 N04 N05 2.58e-12
L05 N04 N05 4.79e-12
R05 N04 N05 3.84e+01
C06 N05 Port2 6.55e-13
L06 N05 Port2 1.57e-11
R06 N05 Port2 8.62e+01
.ENDS GCQ0335C1HR80WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.10e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H9R1CB01
* Property : C = 9.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H9R1CB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 4.60e-02
L04 N03 N04 7.96e-12
R04 N03 N04 8.39e-02
C05 N04 N05 7.10e-11
L05 N04 N05 3.74e-12
R05 N04 N05 2.60e+00
C06 N05 N06 1.52e-11
L06 N05 N06 7.16e-12
R06 N05 N06 1.12e+01
C07 N06 N07 5.82e-11
L07 N06 N07 1.03e-12
R07 N06 N07 2.20e+00
C08 N07 N08 3.39e-11
L08 N07 N08 1.29e-12
R08 N07 N08 2.93e+00
C09 N08 N09 1.47e-11
L09 N08 N09 2.34e-12
R09 N08 N09 3.46e+00
C10 N09 Port2 6.94e-12
L10 N09 Port2 1.71e-12
R10 N09 Port2 9.26e+00
.ENDS GCQ0335C1H9R1CB01

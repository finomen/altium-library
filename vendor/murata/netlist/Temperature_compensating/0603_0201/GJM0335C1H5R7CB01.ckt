*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.70e-06[uF]/50[V]
* Murata P/N :GJM0335C1H5R7CB01
* Property : C = 5.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H5R7CB01 Port1 Port2
C01 Port1 N01 5.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.05e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.07e-12
R04 N03 N04 1.07e-01
C05 N04 N05 8.01e-11
L05 N04 N05 2.17e-12
R05 N04 N05 2.73e+00
C06 N05 N06 7.59e-12
L06 N05 N06 8.72e-12
R06 N05 N06 2.33e+01
C07 N06 N07 7.76e-12
L07 N06 N07 2.88e-12
R07 N06 N07 1.46e+01
C08 N07 Port2 8.24e-13
L08 N07 Port2 1.25e-11
R08 N07 Port2 1.16e+02
.ENDS GJM0335C1H5R7CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GJM0335C1H7R4WB01
* Property : C = 7.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H7R4WB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 5.20e-02
L04 N03 N04 5.42e-12
R04 N03 N04 1.08e-01
C05 N04 N05 5.19e-11
L05 N04 N05 3.90e-12
R05 N04 N05 3.13e+00
C06 N05 N06 1.02e-11
L06 N05 N06 8.16e-12
R06 N05 N06 1.42e+01
C07 N06 N07 9.36e-11
L07 N06 N07 4.76e-13
R07 N06 N07 9.36e-01
C08 N07 N08 7.41e-12
L08 N07 N08 4.29e-12
R08 N07 N08 7.11e+00
C09 N08 N09 1.37e-11
L09 N08 N09 1.16e-12
R09 N08 N09 7.78e+00
C10 N09 Port2 1.02e-12
L10 N09 Port2 1.13e-11
R10 N09 Port2 8.32e+01
.ENDS GJM0335C1H7R4WB01

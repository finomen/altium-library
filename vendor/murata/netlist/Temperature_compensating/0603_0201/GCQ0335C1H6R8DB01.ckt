*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.80e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H6R8DB01
* Property : C = 6.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H6R8DB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 5.60e-02
L04 N03 N04 6.41e-12
R04 N03 N04 9.19e-02
C05 N04 N05 5.58e-11
L05 N04 N05 3.41e-12
R05 N04 N05 2.58e+00
C06 N05 N06 1.11e-11
L06 N05 N06 7.08e-12
R06 N05 N06 1.29e+01
C07 N06 N07 5.92e-11
L07 N06 N07 7.50e-13
R07 N06 N07 1.61e+00
C08 N07 N08 1.51e-11
L08 N07 N08 2.28e-12
R08 N07 N08 3.79e+00
C09 N08 N09 9.79e-12
L09 N08 N09 1.61e-12
R09 N08 N09 6.43e+00
C10 N09 N10 7.84e-12
L10 N09 N10 1.56e-12
R10 N09 N10 7.53e+00
C11 N10 Port2 3.63e-12
L11 N10 Port2 2.80e-12
R11 N10 Port2 1.70e+01
.ENDS GCQ0335C1H6R8DB01

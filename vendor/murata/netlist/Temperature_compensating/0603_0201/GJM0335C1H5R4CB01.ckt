*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.40e-06[uF]/50[V]
* Murata P/N :GJM0335C1H5R4CB01
* Property : C = 5.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H5R4CB01 Port1 Port2
C01 Port1 N01 5.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.13e-12
R04 N03 N04 1.12e-01
C05 N04 N05 7.50e-11
L05 N04 N05 2.18e-12
R05 N04 N05 2.79e+00
C06 N05 N06 8.28e-12
L06 N05 N06 7.61e-12
R06 N05 N06 2.16e+01
C07 N06 N07 8.67e-12
L07 N06 N07 2.44e-12
R07 N06 N07 1.42e+01
C08 N07 Port2 4.64e-12
L08 N07 Port2 2.49e-12
R08 N07 Port2 1.49e+01
.ENDS GJM0335C1H5R4CB01

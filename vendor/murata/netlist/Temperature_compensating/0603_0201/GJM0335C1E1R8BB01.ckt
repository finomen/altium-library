*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-06[uF]/25[V]
* Murata P/N :GJM0335C1E1R8BB01
* Property : C = 1.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E1R8BB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.23e-01
C04 N03 N04 2.76e-11
L04 N03 N04 2.30e-12
R04 N03 N04 9.40e+00
C05 N04 N05 2.86e-12
L05 N04 N05 9.24e-12
R05 N04 N05 7.64e+01
C06 N05 Port2 5.52e-13
L06 N05 Port2 1.67e-11
R06 N05 Port2 1.85e+02
.ENDS GJM0335C1E1R8BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.90e-06[uF]/50[V]
* Murata P/N :GJM0335C1H4R9WB01
* Property : C = 4.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H4R9WB01 Port1 Port2
C01 Port1 N01 4.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.98e-10
R03 N02 N03 9.50e-02
L04 N03 N04 5.95e-12
R04 N03 N04 9.12e-02
C05 N04 N05 8.54e-11
L05 N04 N05 1.56e-12
R05 N04 N05 3.09e+00
C06 N05 N06 6.08e-12
L06 N05 N06 8.27e-12
R06 N05 N06 2.32e+01
C07 N06 N07 1.13e-11
L07 N06 N07 2.15e-12
R07 N06 N07 8.08e+00
C08 N07 N08 4.36e-12
L08 N07 N08 3.84e-12
R08 N07 N08 2.30e+01
C09 N08 Port2 4.09e-13
L09 N08 Port2 2.59e-11
R09 N08 Port2 2.03e+02
.ENDS GJM0335C1H4R9WB01

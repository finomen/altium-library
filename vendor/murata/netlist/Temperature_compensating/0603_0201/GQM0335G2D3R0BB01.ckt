*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/3.00e-06[uF]/200[V]
* Murata P/N :GQM0335G2D3R0BB01
* Property : C = 3.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 1.21e-01
L04 N03 N04 3.56e-12
R04 N03 N04 7.74e-02
C05 N04 N05 4.61e-11
L05 N04 N05 1.44e-12
R05 N04 N05 3.43e+00
C06 N05 N06 8.22e-12
L06 N05 N06 3.98e-12
R06 N05 N06 9.73e+00
C07 N06 N07 4.13e-12
L07 N06 N07 5.06e-12
R07 N06 N07 1.13e+01
C08 N07 N08 5.17e-12
L08 N07 N08 2.93e-12
R08 N07 N08 1.22e+01
C09 N08 Port2 2.00e-12
L09 N08 Port2 5.07e-12
R09 N08 Port2 2.29e+01
.ENDS GQM0335G2D3R0BB01

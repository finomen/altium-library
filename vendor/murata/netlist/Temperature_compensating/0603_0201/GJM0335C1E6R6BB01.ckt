*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/6.60e-06[uF]/25[V]
* Murata P/N :GJM0335C1E6R6BB01
* Property : C = 6.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E6R6BB01 Port1 Port2
C01 Port1 N01 6.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 1.05e-01
L04 N03 N04 4.06e-12
R04 N03 N04 5.25e-02
C05 N04 N05 8.74e-11
L05 N04 N05 2.40e-12
R05 N04 N05 2.51e+00
C06 N05 N06 9.77e-12
L06 N05 N06 8.28e-12
R06 N05 N06 1.87e+01
C07 N06 N07 1.17e-10
L07 N06 N07 3.39e-13
R07 N06 N07 8.96e-01
C08 N07 N08 1.14e-11
L08 N07 N08 2.16e-12
R08 N07 N08 1.17e+01
C09 N08 N09 5.36e-11
L09 N08 N09 3.26e-13
R09 N08 N09 1.39e+00
C10 N09 N10 1.05e-11
L10 N09 N10 1.26e-12
R10 N09 N10 1.08e+01
C11 N10 Port2 1.06e-12
L11 N10 Port2 9.19e-12
R11 N10 Port2 7.55e+01
.ENDS GJM0335C1E6R6BB01

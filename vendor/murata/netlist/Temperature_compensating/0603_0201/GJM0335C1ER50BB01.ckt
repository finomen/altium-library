*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-07[uF]/25[V]
* Murata P/N :GJM0335C1ER50BB01
* Property : C = 5.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1ER50BB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 3.56e-01
C04 N03 N04 3.42e-12
L04 N03 N04 6.59e-12
R04 N03 N04 3.05e+01
C05 N04 N05 8.84e-12
L05 N04 N05 2.24e-12
R05 N04 N05 9.51e+00
C06 N05 Port2 4.50e-13
L06 N05 Port2 2.26e-11
R06 N05 Port2 1.74e+02
.ENDS GJM0335C1ER50BB01

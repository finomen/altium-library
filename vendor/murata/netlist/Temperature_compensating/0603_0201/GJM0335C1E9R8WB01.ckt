*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.80e-06[uF]/25[V]
* Murata P/N :GJM0335C1E9R8WB01
* Property : C = 9.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E9R8WB01 Port1 Port2
C01 Port1 N01 9.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 9.00e-02
L04 N03 N04 6.45e-12
R04 N03 N04 8.79e-02
C05 N04 N05 2.67e-10
L05 N04 N05 1.13e-12
R05 N04 N05 1.18e+00
C06 N05 N06 1.39e-11
L06 N05 N06 8.12e-12
R06 N05 N06 9.16e+00
C07 N06 N07 1.34e-11
L07 N06 N07 2.67e-12
R07 N06 N07 4.81e+00
C08 N07 N08 7.93e-12
L08 N07 N08 2.40e-12
R08 N07 N08 6.39e+00
C09 N08 Port2 9.03e-13
L09 N08 Port2 1.20e-11
R09 N08 Port2 7.52e+01
.ENDS GJM0335C1E9R8WB01

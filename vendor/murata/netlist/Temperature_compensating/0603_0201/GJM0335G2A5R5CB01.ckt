*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/5.50e-06[uF]/100[V]
* Murata P/N :GJM0335G2A5R5CB01
* Property : C = 5.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2A5R5CB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 7.20e-02
L04 N03 N04 5.35e-12
R04 N03 N04 1.02e-01
C05 N04 N05 3.30e-11
L05 N04 N05 4.30e-12
R05 N04 N05 7.99e+00
C06 N05 N06 7.05e-12
L06 N05 N06 8.41e-12
R06 N05 N06 1.62e+01
C07 N06 N07 5.37e-11
L07 N06 N07 6.88e-13
R07 N06 N07 1.47e+00
C08 N07 N08 2.38e-11
L08 N07 N08 1.28e-12
R08 N07 N08 2.14e+00
C09 N08 N09 3.40e-12
L09 N08 N09 3.81e-12
R09 N08 N09 1.98e+01
C10 N09 Port2 1.39e-12
L10 N09 Port2 7.31e-12
R10 N09 Port2 4.67e+01
.ENDS GJM0335G2A5R5CB01

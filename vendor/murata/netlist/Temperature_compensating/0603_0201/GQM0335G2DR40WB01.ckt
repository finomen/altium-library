*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/4.00e-07[uF]/200[V]
* Murata P/N :GQM0335G2DR40WB01
* Property : C = 4.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2DR40WB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 3.38e-01
C04 N03 N04 6.99e-12
L04 N03 N04 2.41e-12
R04 N03 N04 6.53e+00
C05 N04 Port2 1.79e-12
L05 N04 Port2 5.50e-12
R05 N04 Port2 4.29e+01
.ENDS GQM0335G2DR40WB01

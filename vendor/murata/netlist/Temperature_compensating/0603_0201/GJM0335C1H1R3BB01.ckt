*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.30e-06[uF]/50[V]
* Murata P/N :GJM0335C1H1R3BB01
* Property : C = 1.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H1R3BB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 2.60e-01
C04 N03 N04 6.83e-10
L04 N03 N04 9.48e-14
R04 N03 N04 2.29e-01
C05 N04 N05 5.16e-10
L05 N04 N05 1.07e-13
R05 N04 N05 3.01e-01
C06 N05 N06 1.71e-11
L06 N05 N06 2.40e-12
R06 N05 N06 1.02e+01
C07 N06 N07 8.42e-13
L07 N06 N07 2.10e-11
R07 N06 N07 1.61e+02
C08 N07 Port2 1.14e-13
L08 N07 Port2 7.66e-11
R08 N07 Port2 9.10e+02
.ENDS GJM0335C1H1R3BB01

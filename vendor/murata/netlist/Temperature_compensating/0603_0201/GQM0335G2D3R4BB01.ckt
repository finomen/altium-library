*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/3.40e-06[uF]/200[V]
* Murata P/N :GQM0335G2D3R4BB01
* Property : C = 3.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D3R4BB01 Port1 Port2
C01 Port1 N01 3.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 1.12e-01
L04 N03 N04 4.71e-12
R04 N03 N04 8.06e-02
C05 N04 N05 4.69e-11
L05 N04 N05 1.49e-12
R05 N04 N05 3.33e+00
C06 N05 N06 9.59e-12
L06 N05 N06 3.56e-12
R06 N05 N06 8.53e+00
C07 N06 N07 7.35e-12
L07 N06 N07 3.17e-12
R07 N06 N07 8.37e+00
C08 N07 N08 8.12e-12
L08 N07 N08 2.51e-12
R08 N07 N08 6.60e+00
C09 N08 N09 6.51e-12
L09 N08 N09 2.40e-12
R09 N08 N09 1.63e+01
C10 N09 Port2 1.78e-12
L10 N09 Port2 5.92e-12
R10 N09 Port2 3.04e+01
.ENDS GQM0335G2D3R4BB01

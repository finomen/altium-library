*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/4.20e-06[uF]/200[V]
* Murata P/N :GQM0335G2D4R2CB01
* Property : C = 4.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D4R2CB01 Port1 Port2
C01 Port1 N01 4.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.26e-12
R04 N03 N04 8.76e-02
C05 N04 N05 2.76e-11
L05 N04 N05 3.77e-12
R05 N04 N05 6.75e+00
C06 N05 N06 7.04e-12
L06 N05 N06 6.17e-12
R06 N05 N06 1.29e+01
C07 N06 N07 6.29e-12
L07 N06 N07 2.93e-12
R07 N06 N07 1.00e+01
C08 N07 Port2 8.94e-13
L08 N07 Port2 1.12e-11
R08 N07 Port2 9.39e+01
.ENDS GQM0335G2D4R2CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/1.40e-06[uF]/200[V]
* Murata P/N :GQM0335G2D1R4CB01
* Property : C = 1.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D1R4CB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 2.27e-01
C04 N03 N04 4.45e-11
L04 N03 N04 6.70e-13
R04 N03 N04 2.67e+00
C05 N04 N05 8.52e-12
L05 N04 N05 2.41e-12
R05 N04 N05 6.09e+00
C06 N05 N06 1.13e-11
L06 N05 N06 1.58e-12
R06 N05 N06 5.24e+00
C07 N06 Port2 3.12e-12
L07 N06 Port2 3.62e-12
R07 N06 Port2 2.30e+01
.ENDS GQM0335G2D1R4CB01

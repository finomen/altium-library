*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.40e-06[uF]/100[V]
* Murata P/N :GJM0335C2A4R4WB01
* Property : C = 4.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A4R4WB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 8.90e-02
L04 N03 N04 4.17e-12
R04 N03 N04 1.14e-01
C05 N04 N05 4.59e-11
L05 N04 N05 2.35e-12
R05 N04 N05 4.02e+00
C06 N05 N06 7.70e-12
L06 N05 N06 5.92e-12
R06 N05 N06 1.18e+01
C07 N06 N07 7.19e-12
L07 N06 N07 3.44e-12
R07 N06 N07 5.46e+00
C08 N07 N08 1.32e-11
L08 N07 N08 1.40e-12
R08 N07 N08 3.41e+00
C09 N08 Port2 1.58e-12
L09 N08 Port2 6.36e-12
R09 N08 Port2 3.47e+01
.ENDS GJM0335C2A4R4WB01

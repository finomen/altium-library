*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-07[uF]/25[V]
* Murata P/N :GJM0335C1ER80WB01
* Property : C = 8.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1ER80WB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 3.04e-01
C04 N03 N04 2.87e-11
L04 N03 N04 1.11e-12
R04 N03 N04 3.90e+00
C05 N04 N05 3.63e-12
L05 N04 N05 5.96e-12
R05 N04 N05 2.66e+01
C06 N05 N06 1.01e-12
L06 N05 N06 1.14e-11
R06 N05 N06 8.96e+01
C07 N06 Port2 1.14e-12
L07 N06 Port2 9.25e-12
R07 N06 Port2 9.05e+01
.ENDS GJM0335C1ER80WB01

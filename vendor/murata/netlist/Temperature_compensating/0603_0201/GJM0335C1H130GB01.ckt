*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GJM0335C1H130GB01
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H130GB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 4.60e-02
L04 N03 N04 9.00e-12
R04 N03 N04 7.37e-02
C05 N04 N05 1.20e-10
L05 N04 N05 2.88e-12
R05 N04 N05 2.91e+00
C06 N05 N06 1.71e-11
L06 N05 N06 7.86e-12
R06 N05 N06 8.68e+00
C07 N06 N07 1.09e-10
L07 N06 N07 6.68e-13
R07 N06 N07 1.04e+00
C08 N07 N08 2.62e-11
L08 N07 N08 1.99e-12
R08 N07 N08 2.34e+00
C09 N08 Port2 3.74e-12
L09 N08 Port2 5.43e-12
R09 N08 Port2 6.00e+00
.ENDS GJM0335C1H130GB01

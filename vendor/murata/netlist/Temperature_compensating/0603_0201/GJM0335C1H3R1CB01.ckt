*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.10e-06[uF]/50[V]
* Murata P/N :GJM0335C1H3R1CB01
* Property : C = 3.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H3R1CB01 Port1 Port2
C01 Port1 N01 3.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 1.35e-01
L04 N03 N04 4.98e-12
R04 N03 N04 9.33e-02
C05 N04 N05 9.80e-11
L05 N04 N05 6.86e-13
R05 N04 N05 1.40e+00
C06 N05 N06 1.77e-12
L06 N05 N06 1.34e-11
R06 N05 N06 5.70e+01
C07 N06 Port2 3.23e-13
L07 N06 Port2 3.15e-11
R07 N06 Port2 2.86e+02
.ENDS GJM0335C1H3R1CB01

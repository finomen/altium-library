*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/2.00e-06[uF]/100[V]
* Murata P/N :GJM0335G2A2R0CB01
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2A2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 1.98e-01
C04 N03 N04 1.56e-11
L04 N03 N04 2.77e-12
R04 N03 N04 6.67e+00
C05 N04 N05 8.81e-12
L05 N04 N05 3.28e-12
R05 N04 N05 7.25e+00
C06 N05 N06 3.92e-12
L06 N05 N06 3.95e-12
R06 N05 N06 1.04e+01
C07 N06 Port2 2.29e-12
L07 N06 Port2 5.35e-12
R07 N06 Port2 4.65e+01
.ENDS GJM0335G2A2R0CB01

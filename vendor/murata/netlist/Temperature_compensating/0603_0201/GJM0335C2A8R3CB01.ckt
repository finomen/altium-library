*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.30e-06[uF]/100[V]
* Murata P/N :GJM0335C2A8R3CB01
* Property : C = 8.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A8R3CB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 4.80e-02
L04 N03 N04 5.49e-12
R04 N03 N04 1.32e-01
C05 N04 N05 5.57e-11
L05 N04 N05 4.43e-12
R05 N04 N05 3.17e+00
C06 N05 N06 1.41e-11
L06 N05 N06 7.25e-12
R06 N05 N06 1.24e+01
C07 N06 N07 7.75e-11
L07 N06 N07 7.33e-13
R07 N06 N07 1.39e+00
C08 N07 N08 2.29e-11
L08 N07 N08 1.81e-12
R08 N07 N08 3.19e+00
C09 N08 N09 1.71e-11
L09 N08 N09 1.03e-12
R09 N08 N09 4.70e+00
C10 N09 N10 1.20e-11
L10 N09 N10 9.72e-13
R10 N09 N10 6.06e+00
C11 N10 Port2 1.23e-11
L11 N10 Port2 8.30e-13
R11 N10 Port2 9.56e+00
.ENDS GJM0335C2A8R3CB01

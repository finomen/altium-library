*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.30e-06[uF]/200[V]
* Murata P/N :GQM0335C2D2R3BB01
* Property : C = 2.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D2R3BB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-10
R03 N02 N03 1.60e-01
L04 N03 N04 2.35e-12
R04 N03 N04 2.96e-02
C05 N04 N05 1.89e-11
L05 N04 N05 3.13e-12
R05 N04 N05 9.20e+00
C06 N05 N06 5.87e-12
L06 N05 N06 5.20e-12
R06 N05 N06 1.12e+01
C07 N06 N07 2.93e-12
L07 N06 N07 5.33e-12
R07 N06 N07 2.74e+01
C08 N07 Port2 1.14e-12
L08 N07 Port2 8.98e-12
R08 N07 Port2 7.06e+01
.ENDS GQM0335C2D2R3BB01

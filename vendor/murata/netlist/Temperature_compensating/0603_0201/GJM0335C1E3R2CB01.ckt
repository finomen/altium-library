*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.20e-06[uF]/25[V]
* Murata P/N :GJM0335C1E3R2CB01
* Property : C = 3.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E3R2CB01 Port1 Port2
C01 Port1 N01 3.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.30e-01
L04 N03 N04 4.83e-12
R04 N03 N04 8.16e-02
C05 N04 N05 7.07e-11
L05 N04 N05 1.08e-12
R05 N04 N05 2.49e+00
C06 N05 N06 3.48e-12
L06 N05 N06 8.76e-12
R06 N05 N06 3.82e+01
C07 N06 Port2 1.42e-13
L07 N06 Port2 7.23e-11
R07 N06 Port2 5.27e+02
.ENDS GJM0335C1E3R2CB01

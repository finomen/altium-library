*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.20e-06[uF]/25[V]
* Murata P/N :GJM0335C1E8R2CB01
* Property : C = 8.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.33e-10
R03 N02 N03 1.00e-01
L04 N03 N04 6.51e-12
R04 N03 N04 1.19e-01
C05 N04 N05 2.13e-10
L05 N04 N05 9.84e-13
R05 N04 N05 1.04e+00
C06 N05 N06 1.06e-11
L06 N05 N06 7.36e-12
R06 N05 N06 1.06e+01
C07 N06 N07 3.13e-12
L07 N06 N07 7.07e-12
R07 N06 N07 1.13e+01
C08 N07 N08 7.07e-12
L08 N07 N08 1.81e-12
R08 N07 N08 8.32e+00
C09 N08 Port2 9.42e-13
L09 N08 Port2 1.10e-11
R09 N08 Port2 7.28e+01
.ENDS GJM0335C1E8R2CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.70e-05[uF]/25[V]
* Murata P/N :GJM0335C1E270GB01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.02e-10
R03 N02 N03 9.00e-02
L04 N03 N04 7.30e-12
R04 N03 N04 9.74e-02
C05 N04 N05 1.39e-12
L05 N04 N05 1.22e-10
C06 N05 N06 3.58e-11
L06 N05 N06 1.08e-11
R06 N05 N06 6.22e+00
C07 N06 Port2 2.84e-10
L07 N06 Port2 3.40e-12
R07 N06 Port2 1.44e+00
.ENDS GJM0335C1E270GB01

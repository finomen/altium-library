*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.80e-05[uF]/100[V]
* Murata P/N :GJM0335C2A180JB01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 3.30e-02
L04 N03 N04 7.74e-12
R04 N03 N04 8.86e-02
C05 N04 N05 1.66e-10
L05 N04 N05 2.85e-12
R05 N04 N05 2.26e+00
C06 N05 N06 2.43e-11
L06 N05 N06 7.36e-12
R06 N05 N06 6.88e+00
C07 N06 N07 1.26e-10
L07 N06 N07 7.35e-13
R07 N06 N07 7.04e-01
C08 N07 N08 3.09e-11
L08 N07 N08 2.04e-12
R08 N07 N08 2.33e+00
C09 N08 N09 3.58e-11
L09 N08 N09 1.21e-12
R09 N08 N09 1.37e+00
C10 N09 Port2 4.47e-12
L10 N09 Port2 4.60e-12
R10 N09 Port2 8.46e+00
.ENDS GJM0335C2A180JB01

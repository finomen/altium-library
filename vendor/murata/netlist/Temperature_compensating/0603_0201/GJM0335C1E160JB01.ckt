*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.60e-05[uF]/25[V]
* Murata P/N :GJM0335C1E160JB01
* Property : C = 1.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 7.20e-02
L04 N03 N04 8.77e-12
R04 N03 N04 7.94e-02
C05 N04 N05 3.56e-10
L05 N04 N05 1.75e-12
R05 N04 N05 9.84e-01
C06 N05 N06 3.12e-11
L06 N05 N06 8.16e-12
R06 N05 N06 6.15e+00
C07 N06 N07 3.19e-11
L07 N06 N07 2.52e-12
R07 N06 N07 3.30e+00
C08 N07 N08 3.11e-11
L08 N07 N08 1.30e-12
R08 N07 N08 2.51e+00
C09 N08 N09 2.90e-12
L09 N08 N09 6.36e-12
R09 N08 N09 1.54e+01
C10 N09 Port2 5.00e-13
L10 N09 Port2 2.00e-11
R10 N09 Port2 1.20e+02
.ENDS GJM0335C1E160JB01

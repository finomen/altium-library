*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/6.50e-06[uF]/100[V]
* Murata P/N :GJM0335G2A6R5WB01
* Property : C = 6.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335G2A6R5WB01 Port1 Port2
C01 Port1 N01 6.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 5.80e-02
L04 N03 N04 6.97e-12
R04 N03 N04 9.12e-02
C05 N04 N05 5.90e-11
L05 N04 N05 3.15e-12
R05 N04 N05 3.28e+00
C06 N05 N06 9.49e-12
L06 N05 N06 8.04e-12
R06 N05 N06 1.53e+01
C07 N06 N07 5.28e-11
L07 N06 N07 8.12e-13
R07 N06 N07 1.58e+00
C08 N07 N08 1.76e-11
L08 N07 N08 1.88e-12
R08 N07 N08 4.08e+00
C09 N08 Port2 1.00e-11
L09 N08 Port2 1.58e-12
R09 N08 Port2 6.23e+00
.ENDS GJM0335G2A6R5WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.90e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H1R9BB01
* Property : C = 1.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H1R9BB01 Port1 Port2
C01 Port1 N01 1.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.90e-10
R03 N02 N03 2.04e-01
C04 N03 N04 7.55e-11
L04 N03 N04 5.17e-13
R04 N03 N04 1.66e+00
C05 N04 N05 1.99e-11
L05 N04 N05 1.34e-12
R05 N04 N05 3.44e+00
C06 N05 N06 5.52e-12
L06 N05 N06 3.88e-12
R06 N05 N06 6.65e+00
C07 N06 Port2 2.20e-12
L07 N06 Port2 5.36e-12
R07 N06 Port2 4.32e+01
.ENDS GCQ0335C1H1R9BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.00e-06[uF]/100[V]
* Murata P/N :GJM0335C2A5R0WB01
* Property : C = 5.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A5R0WB01 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 7.70e-02
L04 N03 N04 4.45e-12
R04 N03 N04 1.39e-01
C05 N04 N05 3.10e-11
L05 N04 N05 4.28e-12
R05 N04 N05 7.26e+00
C06 N05 N06 7.64e-12
L06 N05 N06 7.16e-12
R06 N05 N06 1.45e+01
C07 N06 N07 4.22e-12
L07 N06 N07 5.00e-12
R07 N06 N07 6.04e+00
C08 N07 N08 6.23e-12
L08 N07 N08 2.01e-12
R08 N07 N08 1.36e+01
C09 N08 Port2 2.34e-12
L09 N08 Port2 4.38e-12
R09 N08 Port2 3.24e+01
.ENDS GJM0335C2A5R0WB01

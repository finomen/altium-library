*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.60e-06[uF]/50[V]
* Murata P/N :GJM0335C1H2R6CB01
* Property : C = 2.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H2R6CB01 Port1 Port2
C01 Port1 N01 2.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-10
R03 N02 N03 1.40e-01
L04 N03 N04 5.02e-12
R04 N03 N04 1.15e-01
C05 N04 N05 6.35e-11
L05 N04 N05 8.46e-13
R05 N04 N05 2.73e+00
C06 N05 N06 1.60e-12
L06 N05 N06 1.21e-11
R06 N05 N06 7.87e+01
C07 N06 Port2 2.40e-13
L07 N06 Port2 4.02e-11
R07 N06 Port2 5.47e+02
.ENDS GJM0335C1H2R6CB01

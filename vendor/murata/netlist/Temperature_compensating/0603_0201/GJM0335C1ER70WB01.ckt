*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.00e-07[uF]/25[V]
* Murata P/N :GJM0335C1ER70WB01
* Property : C = 7.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1ER70WB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 3.20e-01
L04 N03 N04 7.59e-13
R04 N03 N04 3.34e-01
C05 N04 N05 6.35e-12
L05 N04 N05 4.15e-12
R05 N04 N05 1.52e+01
C06 N05 N06 7.57e-12
L06 N05 N06 3.10e-12
R06 N05 N06 1.51e+01
C07 N06 Port2 9.15e-13
L07 N06 Port2 1.14e-11
R07 N06 Port2 1.31e+02
.ENDS GJM0335C1ER70WB01

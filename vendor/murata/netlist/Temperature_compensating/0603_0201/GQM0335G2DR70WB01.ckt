*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/7.00e-07[uF]/200[V]
* Murata P/N :GQM0335G2DR70WB01
* Property : C = 7.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2DR70WB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 2.82e-01
C04 N03 N04 1.35e-11
L04 N03 N04 1.55e-12
R04 N03 N04 4.35e+00
C05 N04 N05 1.10e-11
L05 N04 N05 1.62e-12
R05 N04 N05 5.57e+00
C06 N05 Port2 1.70e-12
L06 N05 Port2 6.08e-12
R06 N05 Port2 3.43e+01
.ENDS GQM0335G2DR70WB01

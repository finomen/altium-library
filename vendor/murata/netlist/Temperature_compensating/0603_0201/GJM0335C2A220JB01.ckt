*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.20e-05[uF]/100[V]
* Murata P/N :GJM0335C2A220JB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C2A220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.62e-10
R03 N02 N03 3.10e-02
L04 N03 N04 1.50e-11
R04 N03 N04 6.37e-02
C05 N04 N05 1.38e-10
L05 N04 N05 4.80e-12
R05 N04 N05 3.79e+00
C06 N05 N06 3.73e-11
L06 N05 N06 6.98e-12
R06 N05 N06 6.10e+00
C07 N06 N07 1.44e-10
L07 N06 N07 9.05e-13
R07 N06 N07 7.82e-01
C08 N07 N08 3.25e-11
L08 N07 N08 2.65e-12
R08 N07 N08 2.37e+00
C09 N08 N09 2.14e-11
L09 N08 N09 1.50e-12
R09 N08 N09 2.85e+00
C10 N09 N10 7.95e-12
L10 N09 N10 2.53e-12
R10 N09 N10 3.75e+00
C11 N10 Port2 1.40e-11
L11 N10 Port2 7.40e-13
R11 N10 Port2 1.04e+01
.ENDS GJM0335C2A220JB01

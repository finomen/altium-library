*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/5.60e-06[uF]/200[V]
* Murata P/N :GQM0335C2D5R6WB01
* Property : C = 5.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335C2D5R6WB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 7.00e-02
L04 N03 N04 4.84e-12
R04 N03 N04 1.30e-01
C05 N04 N05 3.71e-11
L05 N04 N05 3.95e-12
R05 N04 N05 5.93e+00
C06 N05 N06 8.58e-12
L06 N05 N06 7.09e-12
R06 N05 N06 1.40e+01
C07 N06 N07 4.99e-11
L07 N06 N07 7.25e-13
R07 N06 N07 1.49e+00
C08 N07 N08 2.31e-11
L08 N07 N08 1.36e-12
R08 N07 N08 3.25e+00
C09 N08 Port2 7.82e-12
L09 N08 Port2 1.63e-12
R09 N08 Port2 1.00e+01
.ENDS GQM0335C2D5R6WB01

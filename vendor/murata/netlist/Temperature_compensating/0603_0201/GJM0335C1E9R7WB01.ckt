*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.70e-06[uF]/25[V]
* Murata P/N :GJM0335C1E9R7WB01
* Property : C = 9.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E9R7WB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.92e-10
R03 N02 N03 9.50e-02
L04 N03 N04 6.26e-12
R04 N03 N04 6.55e-02
C05 N04 N05 1.89e-10
L05 N04 N05 1.47e-12
R05 N04 N05 1.29e+00
C06 N05 N06 1.31e-11
L06 N05 N06 8.01e-12
R06 N05 N06 9.60e+00
C07 N06 N07 1.19e-11
L07 N06 N07 2.85e-12
R07 N06 N07 7.59e+00
C08 N07 N08 3.58e-12
L08 N07 N08 5.97e-12
R08 N07 N08 1.09e+01
C09 N08 N09 8.73e-12
L09 N08 N09 1.94e-12
R09 N08 N09 1.10e+01
C10 N09 Port2 3.05e-13
L10 N09 Port2 3.39e-11
R10 N09 Port2 1.25e+02
.ENDS GJM0335C1E9R7WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.30e-06[uF]/50[V]
* Murata P/N :GJM0335C1H4R3BB01
* Property : C = 4.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 1.00e-01
L04 N03 N04 4.70e-12
R04 N03 N04 1.04e-01
C05 N04 N05 1.20e-10
L05 N04 N05 9.47e-13
R05 N04 N05 1.91e+00
C06 N05 N06 3.74e-12
L06 N05 N06 1.13e-11
R06 N05 N06 4.25e+01
C07 N06 N07 1.02e-11
L07 N06 N07 1.47e-12
R07 N06 N07 7.79e+00
C08 N07 N08 8.17e-13
L08 N07 N08 1.68e-11
R08 N07 N08 1.15e+02
C09 N08 Port2 1.32e-13
L09 N08 Port2 8.16e-11
R09 N08 Port2 1.27e+03
.ENDS GJM0335C1H4R3BB01

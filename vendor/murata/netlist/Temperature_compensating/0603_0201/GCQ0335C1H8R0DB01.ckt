*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCQ0335C1H8R0DB01
* Property : C = 8.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ0335C1H8R0DB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.52e-10
R03 N02 N03 5.33e-02
L04 N03 N04 5.63e-12
R04 N03 N04 8.27e-02
C05 N04 N05 5.39e-11
L05 N04 N05 4.51e-12
R05 N04 N05 3.08e+00
C06 N05 N06 1.21e-11
L06 N05 N06 8.25e-12
R06 N05 N06 1.28e+01
C07 N06 N07 5.48e-11
L07 N06 N07 1.00e-12
R07 N06 N07 2.27e+00
C08 N07 N08 2.32e-11
L08 N07 N08 1.71e-12
R08 N07 N08 3.53e+00
C09 N08 N09 1.24e-11
L09 N08 N09 2.53e-12
R09 N08 N09 4.17e+00
C10 N09 N10 1.04e-11
L10 N09 N10 1.70e-12
R10 N09 N10 4.78e+00
C11 N10 Port2 3.57e-12
L11 N10 Port2 3.28e-12
R11 N10 Port2 1.36e+01
.ENDS GCQ0335C1H8R0DB01

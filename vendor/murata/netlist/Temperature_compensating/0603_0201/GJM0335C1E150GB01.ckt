*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GJM0335C1E150GB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 7.50e-02
L04 N03 N04 9.78e-12
R04 N03 N04 6.97e-02
C05 N04 N05 2.32e-10
L05 N04 N05 2.29e-12
R05 N04 N05 1.50e+00
C06 N05 N06 2.51e-11
L06 N05 N06 8.33e-12
R06 N05 N06 7.23e+00
C07 N06 N07 2.31e-11
L07 N06 N07 2.80e-12
R07 N06 N07 3.88e+00
C08 N07 N08 2.51e-11
L08 N07 N08 1.31e-12
R08 N07 N08 2.63e+00
C09 N08 N09 7.29e-12
L09 N08 N09 2.74e-12
R09 N08 N09 7.23e+00
C10 N09 Port2 1.29e-12
L10 N09 Port2 7.94e-12
R10 N09 Port2 3.80e+01
.ENDS GJM0335C1E150GB01

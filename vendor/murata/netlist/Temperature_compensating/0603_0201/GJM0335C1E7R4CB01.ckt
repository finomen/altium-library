*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/7.40e-06[uF]/25[V]
* Murata P/N :GJM0335C1E7R4CB01
* Property : C = 7.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E7R4CB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.25e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.67e-12
R04 N03 N04 1.11e-01
C05 N04 N05 4.29e-10
L05 N04 N05 5.15e-13
R05 N04 N05 6.74e-01
C06 N05 N06 1.01e-11
L06 N05 N06 8.37e-12
R06 N05 N06 9.29e+00
C07 N06 N07 7.27e-12
L07 N06 N07 3.52e-12
R07 N06 N07 8.11e+00
C08 N07 N08 4.39e-12
L08 N07 N08 3.22e-12
R08 N07 N08 1.54e+01
C09 N08 Port2 3.03e-13
L09 N08 Port2 3.38e-11
R09 N08 Port2 4.61e+02
.ENDS GJM0335C1E7R4CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.00e-05[uF]/25[V]
* Murata P/N :GJM0335C1E100GB01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E100GB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 8.50e-02
L04 N03 N04 9.13e-12
R04 N03 N04 7.32e-02
C05 N04 N05 1.74e-10
L05 N04 N05 2.06e-12
R05 N04 N05 1.99e+00
C06 N05 N06 1.64e-11
L06 N05 N06 8.87e-12
R06 N05 N06 9.40e+00
C07 N06 N07 1.78e-11
L07 N06 N07 2.69e-12
R07 N06 N07 4.82e+00
C08 N07 N08 2.14e-11
L08 N07 N08 1.27e-12
R08 N07 N08 2.77e+00
C09 N08 N09 1.56e-11
L09 N08 N09 1.35e-12
R09 N08 N09 4.71e+00
C10 N09 N10 8.79e-12
L10 N09 N10 1.94e-12
R10 N09 N10 5.05e+00
C11 N10 Port2 7.03e-13
L11 N10 Port2 1.60e-11
R11 N10 Port2 9.61e+01
.ENDS GJM0335C1E100GB01

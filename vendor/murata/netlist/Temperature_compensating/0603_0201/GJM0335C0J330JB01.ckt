*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/3.30e-05[uF]/6.3[V]
* Murata P/N :GJM0335C0J330JB01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C0J330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 6.03e-02
L04 N03 N04 8.95e-12
R04 N03 N04 9.02e-02
C05 N04 N05 4.76e-10
L05 N04 N05 2.84e-12
R05 N04 N05 1.04e+00
C06 N05 N06 4.36e-11
L06 N05 N06 1.34e-11
R06 N05 N06 5.73e+00
C07 N06 N07 7.78e-11
L07 N06 N07 4.26e-12
R07 N06 N07 8.86e-01
C08 N07 Port2 4.01e-12
L08 N07 Port2 5.92e-11
R08 N07 Port2 1.00e+05
.ENDS GJM0335C0J330JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.20e-06[uF]/25[V]
* Murata P/N :GJM0335C1E1R2WB01
* Property : C = 1.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E1R2WB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.36e-10
R03 N02 N03 2.90e-01
C04 N03 N04 4.55e-10
L04 N03 N04 1.45e-13
R04 N03 N04 2.45e-01
C05 N04 N05 7.63e-10
L05 N04 N05 7.44e-14
R05 N04 N05 2.10e-01
C06 N05 N06 9.43e-12
L06 N05 N06 3.32e-12
R06 N05 N06 1.64e+01
C07 N06 Port2 1.15e-12
L07 N06 Port2 1.14e-11
R07 N06 Port2 1.27e+02
.ENDS GJM0335C1E1R2WB01

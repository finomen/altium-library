*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.30e-06[uF]/50[V]
* Murata P/N :GJM0335C1H2R3WB01
* Property : C = 2.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H2R3WB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.30e-10
R03 N02 N03 1.60e-01
L04 N03 N04 4.06e-12
R04 N03 N04 1.02e-01
C05 N04 N05 3.50e-11
L05 N04 N05 1.29e-12
R05 N04 N05 4.38e+00
C06 N05 N06 1.81e-12
L06 N05 N06 8.99e-12
R06 N05 N06 5.27e+01
C07 N06 Port2 4.29e-13
L07 N06 Port2 2.32e-11
R07 N06 Port2 1.70e+02
.ENDS GJM0335C1H2R3WB01

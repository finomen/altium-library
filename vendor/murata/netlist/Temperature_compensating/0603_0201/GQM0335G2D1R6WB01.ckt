*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/1.60e-06[uF]/200[V]
* Murata P/N :GQM0335G2D1R6WB01
* Property : C = 1.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D1R6WB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.76e-10
R03 N02 N03 2.08e-01
C04 N03 N04 9.32e-12
L04 N03 N04 3.88e-12
R04 N03 N04 1.02e+01
C05 N04 N05 4.75e-12
L05 N04 N05 5.14e-12
R05 N04 N05 1.30e+01
C06 N05 N06 2.07e-12
L06 N05 N06 6.23e-12
R06 N05 N06 1.93e+01
C07 N06 N07 1.53e-12
L07 N06 N07 7.62e-12
R07 N06 N07 7.37e+01
C08 N07 Port2 1.73e-12
L08 N07 Port2 5.91e-12
R08 N07 Port2 4.32e+01
.ENDS GQM0335G2D1R6WB01

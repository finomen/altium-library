*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.10e-05[uF]/25[V]
* Murata P/N :GJM0335C1E110GB01
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.85e-10
R03 N02 N03 8.30e-02
L04 N03 N04 7.43e-12
R04 N03 N04 8.46e-02
C05 N04 N05 2.14e-10
L05 N04 N05 1.63e-12
R05 N04 N05 1.27e+00
C06 N05 N06 1.70e-11
L06 N05 N06 7.93e-12
R06 N05 N06 9.55e+00
C07 N06 N07 1.47e-10
L07 N06 N07 4.43e-13
R07 N06 N07 6.47e-01
C08 N07 N08 1.49e-11
L08 N07 N08 2.79e-12
R08 N07 N08 5.90e+00
C09 N08 N09 6.53e-12
L09 N08 N09 3.25e-12
R09 N08 N09 8.53e+00
C10 N09 N10 1.01e-11
L10 N09 N10 1.39e-12
R10 N09 N10 7.61e+00
C11 N10 Port2 2.90e-13
L11 N10 Port2 3.58e-11
R11 N10 Port2 3.32e+02
.ENDS GJM0335C1E110GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.40e-05[uF]/25[V]
* Murata P/N :GJM0335C1E240GB01
* Property : C = 2.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 6.71e-02
L04 N03 N04 5.95e-12
R04 N03 N04 1.37e-01
C05 N04 N05 2.69e-10
L05 N04 N05 3.02e-12
R05 N04 N05 1.21e+00
C06 N05 Port2 1.44e-11
L06 N05 Port2 2.10e-11
R06 N05 Port2 1.14e+01
.ENDS GJM0335C1E240GB01

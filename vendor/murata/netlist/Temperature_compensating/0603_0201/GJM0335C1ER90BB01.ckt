*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/9.00e-07[uF]/25[V]
* Murata P/N :GJM0335C1ER90BB01
* Property : C = 9.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1ER90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.09e-10
R03 N02 N03 2.90e-01
C04 N03 N04 3.12e-12
L04 N03 N04 7.01e-12
R04 N03 N04 2.78e+01
C05 N04 N05 3.99e-12
L05 N04 N05 4.17e-12
R05 N04 N05 2.66e+01
C06 N05 Port2 6.27e-13
L06 N05 Port2 1.61e-11
R06 N05 Port2 1.19e+02
.ENDS GJM0335C1ER90BB01

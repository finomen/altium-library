*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/X8G(-55to150[deg])/1.20e-05[uF]/200[V]
* Murata P/N :GQM0335G2D120GB01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM0335G2D120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.53e-10
R03 N02 N03 4.90e-02
L04 N03 N04 6.51e-12
R04 N03 N04 8.32e-02
C05 N04 N05 9.61e-11
L05 N04 N05 3.24e-12
R05 N04 N05 3.54e+00
C06 N05 N06 1.66e-11
L06 N05 N06 7.36e-12
R06 N05 N06 9.56e+00
C07 N06 N07 1.47e-10
L07 N06 N07 4.39e-13
R07 N06 N07 6.61e-01
C08 N07 N08 4.76e-11
L08 N07 N08 9.82e-13
R08 N07 N08 1.82e+00
C09 N08 N09 6.86e-12
L09 N08 N09 3.86e-12
R09 N08 N09 8.13e+00
C10 N09 Port2 7.29e-12
L10 N09 Port2 2.52e-12
R10 N09 Port2 2.63e+00
.ENDS GQM0335G2D120GB01

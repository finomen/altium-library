*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GJM0335C1HR20WB01
* Property : C = 2.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1HR20WB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.32e-10
R03 N02 N03 5.44e-01
L04 N03 N04 1.21e-12
R04 N03 N04 4.39e-01
C05 N04 N05 7.48e-12
L05 N04 N05 1.69e-12
R05 N04 N05 1.23e+01
C06 N05 Port2 5.20e-12
L06 N05 Port2 2.13e-12
R06 N05 Port2 1.21e+01
.ENDS GJM0335C1HR20WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/4.00e-06[uF]/50[V]
* Murata P/N :GJM0335C1H4R0WB01
* Property : C = 4.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1H4R0WB01 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 1.03e-01
L04 N03 N04 4.21e-12
R04 N03 N04 8.78e-02
C05 N04 N05 7.03e-11
L05 N04 N05 1.48e-12
R05 N04 N05 2.89e+00
C06 N05 N06 3.46e-12
L06 N05 N06 1.12e-11
R06 N05 N06 3.85e+01
C07 N06 N07 7.29e-13
L07 N06 N07 1.80e-11
R07 N06 N07 1.52e+02
C08 N07 Port2 1.95e-13
L08 N07 Port2 5.57e-11
R08 N07 Port2 2.93e+02
.ENDS GJM0335C1H4R0WB01

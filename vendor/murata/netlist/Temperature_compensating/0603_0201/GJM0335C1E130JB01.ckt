*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/C0G(-55to125[deg])/1.30e-05[uF]/25[V]
* Murata P/N :GJM0335C1E130JB01
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0335C1E130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 7.80e-02
L04 N03 N04 8.65e-12
R04 N03 N04 7.66e-02
C05 N04 N05 2.51e-10
L05 N04 N05 1.71e-12
R05 N04 N05 1.20e+00
C06 N05 N06 1.98e-11
L06 N05 N06 8.36e-12
R06 N05 N06 8.25e+00
C07 N06 N07 2.03e-11
L07 N06 N07 2.52e-12
R07 N06 N07 4.53e+00
C08 N07 N08 3.77e-12
L08 N07 N08 5.63e-12
R08 N07 N08 8.84e+00
C09 N08 N09 1.11e-11
L09 N08 N09 1.44e-12
R09 N08 N09 5.58e+00
C10 N09 Port2 6.27e-13
L10 N09 Port2 1.66e-11
R10 N09 Port2 7.02e+01
.ENDS GJM0335C1E130JB01

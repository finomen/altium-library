*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R0BB01
* Property : C = 1.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.99e-10
R03 N02 N03 2.29e-01
C04 N03 N04 2.45e-11
L04 N03 N04 2.90e-12
R04 N03 N04 6.67e+00
C05 N04 N05 8.86e-12
L05 N04 N05 5.21e-12
R05 N04 N05 1.51e+01
C06 N05 Port2 3.21e-13
L06 N05 Port2 1.21e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2D1R0BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.20e-05[uF]/50[V]
* Murata P/N :GJM1555C1H120GB01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.70e-11
R03 N02 N03 8.00e-02
L04 N03 N04 5.86e-12
R04 N03 N04 7.37e-02
C05 N04 N05 1.34e-12
L05 N04 N05 1.71e-10
C06 N05 N06 2.34e-11
L06 N05 N06 1.35e-11
R06 N05 N06 7.91e+00
C07 N06 Port2 6.03e-11
L07 N06 Port2 1.17e-11
R07 N06 Port2 1.17e+01
.ENDS GJM1555C1H120GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.50e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR75CB01
* Property : C = 7.50e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR75CB01 Port1 Port2
C01 Port1 N01 7.50e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 2.83e-01
C04 N03 N04 3.84e-12
L04 N03 N04 1.60e-11
R04 N03 N04 9.17e+01
C05 N04 Port2 1.14e-12
L05 N04 Port2 4.21e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR75CB01

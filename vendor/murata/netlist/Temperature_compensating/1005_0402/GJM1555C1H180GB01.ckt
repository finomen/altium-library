*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/50[V]
* Murata P/N :GJM1555C1H180GB01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-11
R03 N02 N03 8.00e-02
L04 N03 N04 3.12e-12
R04 N03 N04 3.92e-02
C05 N04 N05 9.44e-13
L05 N04 N05 1.99e-10
C06 N05 N06 6.96e-12
L06 N05 N06 3.01e-11
R06 N05 N06 2.23e+01
C07 N06 N07 1.17e-11
L07 N06 N07 3.80e-11
R07 N06 N07 4.21e+01
C08 N07 Port2 8.73e-11
L08 N07 Port2 1.21e-11
R08 N07 Port2 1.06e+01
.ENDS GJM1555C1H180GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R8CB01
* Property : C = 1.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.57e-10
R03 N02 N03 1.30e-01
L04 N03 N04 3.36e-12
R04 N03 N04 7.59e-02
C05 N04 Port2 8.36e-11
L05 N04 Port2 3.77e-12
R05 N04 Port2 2.78e+00
.ENDS GQM1555C2D1R8CB01

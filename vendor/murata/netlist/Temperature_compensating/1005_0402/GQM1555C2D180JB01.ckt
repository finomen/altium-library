*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.80e-05[uF]/200[V]
* Murata P/N :GQM1555C2D180JB01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D180JB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.28e-10
R03 N02 N03 1.02e-01
L04 N03 N04 3.13e-11
R04 N03 N04 8.54e+00
C05 N04 N05 7.53e-11
L05 N04 N05 1.45e-11
R05 N04 N05 1.11e+01
C06 N05 N06 3.27e-11
L06 N05 N06 1.40e-11
R06 N05 N06 1.66e+01
C07 N06 Port2 1.64e-11
L07 N06 Port2 1.85e-11
R07 N06 Port2 6.95e+00
.ENDS GQM1555C2D180JB01

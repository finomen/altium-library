*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H6R0DE01
* Property : C = 6.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H6R0DE01 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.95e-10
R03 N02 N03 1.27e-01
L04 N03 N04 1.90e-11
R04 N03 N04 5.49e-01
L05 N04 N05 2.55e-11
R05 N04 N05 1.29e-01
C06 N05 N06 9.19e-11
L06 N05 N06 5.36e-12
R06 N05 N06 1.38e+00
C07 N06 Port2 1.73e-12
L07 N06 Port2 1.06e-10
R07 N06 Port2 1.00e+05
.ENDS GCH1555C1H6R0DE01

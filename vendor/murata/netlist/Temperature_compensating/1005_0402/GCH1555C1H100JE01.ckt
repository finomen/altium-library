*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/50[V]
* Murata P/N :GCH1555C1H100JE01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H100JE01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.83e-10
R03 N02 N03 1.11e-01
L04 N03 N04 1.32e-11
R04 N03 N04 2.11e-01
L05 N04 N05 3.26e-11
R05 N04 N05 8.18e-02
C06 N05 N06 3.81e-11
L06 N05 N06 2.36e-11
R06 N05 N06 5.83e+00
C07 N06 Port2 9.48e-12
L07 N06 Port2 2.70e-11
R07 N06 Port2 4.13e+00
.ENDS GCH1555C1H100JE01

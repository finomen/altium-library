*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-06[uF]/50[V]
* Murata P/N :GJM1555C1H2R2BB01
* Property : C = 2.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H2R2BB01 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.04e-10
R03 N02 N03 1.90e-01
L04 N03 N04 3.91e-12
R04 N03 N04 1.20e-01
C05 N04 N05 6.03e-10
L05 N04 N05 6.02e-13
R05 N04 N05 7.16e-02
C06 N05 Port2 2.93e-11
L06 N05 Port2 1.06e-11
R06 N05 Port2 1.00e+05
.ENDS GJM1555C1H2R2BB01

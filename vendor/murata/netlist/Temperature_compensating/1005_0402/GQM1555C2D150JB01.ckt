*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/200[V]
* Murata P/N :GQM1555C2D150JB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.29e-10
R03 N02 N03 1.03e-01
C04 N03 N04 6.07e-11
L04 N03 N04 1.52e-11
R04 N03 N04 1.03e+01
C05 N04 N05 2.50e-11
L05 N04 N05 1.59e-11
R05 N04 N05 1.72e+01
C06 N05 Port2 2.29e-11
L06 N05 Port2 1.12e-11
R06 N05 Port2 4.10e+01
.ENDS GQM1555C2D150JB01

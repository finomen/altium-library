*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R7DB01
* Property : C = 6.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R7DB01 Port1 Port2
C01 Port1 N01 6.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.30e-10
R03 N02 N03 8.83e-02
L04 N03 Port2 1.44e-11
R04 N03 Port2 7.70e-01
.ENDS GCQ1555C1H6R7DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R0CB01
* Property : C = 8.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R0CB01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.96e-10
R03 N02 N03 7.86e-02
L04 N03 N04 5.11e-12
R04 N03 N04 7.28e-02
C05 N04 N05 2.38e-11
L05 N04 N05 2.14e-11
R05 N04 N05 2.64e+01
C06 N05 Port2 5.20e-12
L06 N05 Port2 4.90e-11
R06 N05 Port2 5.45e+02
.ENDS GQM1555C2D8R0CB01

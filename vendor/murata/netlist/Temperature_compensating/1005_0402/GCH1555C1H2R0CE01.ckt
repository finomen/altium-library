*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H2R0CE01
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H2R0CE01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.36e-10
R03 N02 N03 2.09e-01
L04 N03 N04 2.51e-11
R04 N03 N04 1.31e+00
L05 N04 Port2 2.53e-11
R05 N04 Port2 1.59e-01
.ENDS GCH1555C1H2R0CE01

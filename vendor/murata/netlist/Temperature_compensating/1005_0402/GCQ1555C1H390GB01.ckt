*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.90e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H390GB01
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.93e-10
R03 N02 N03 7.00e-02
C04 N03 N04 1.86e-10
L04 N03 N04 1.33e-11
R04 N03 N04 6.39e+00
C05 N04 N05 5.35e-11
L05 N04 N05 1.94e-11
R05 N04 N05 1.35e+01
C06 N05 N06 1.09e-10
L06 N05 N06 4.73e-12
R06 N05 N06 2.81e+00
C07 N06 N07 1.05e-10
L07 N06 N07 3.24e-12
R07 N06 N07 2.69e+00
C08 N07 Port2 4.72e-12
L08 N07 Port2 5.63e-11
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H390GB01

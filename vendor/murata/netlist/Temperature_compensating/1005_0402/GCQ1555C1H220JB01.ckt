*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H220JB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H220JB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 7.50e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.61e-11
R04 N03 N04 1.11e+01
C05 N04 N05 2.33e-11
L05 N04 N05 2.54e-11
R05 N04 N05 2.60e+01
C06 N05 Port2 4.91e-12
L06 N05 Port2 5.74e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H220JB01

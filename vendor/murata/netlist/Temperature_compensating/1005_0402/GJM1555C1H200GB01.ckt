*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-05[uF]/50[V]
* Murata P/N :GJM1555C1H200GB01
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H200GB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-11
R03 N02 N03 7.29e-02
L04 N03 N04 4.01e-12
R04 N03 N04 1.09e-01
C05 N04 N05 8.66e-11
L05 N04 N05 1.42e-11
R05 N04 N05 1.29e+01
C06 N05 N06 1.61e-11
L06 N05 N06 3.23e-11
R06 N05 N06 4.06e+01
C07 N06 N07 2.40e-11
L07 N06 N07 1.15e-11
R07 N06 N07 2.15e+01
C08 N07 Port2 9.84e-13
L08 N07 Port2 2.08e-10
R08 N07 Port2 1.00e+05
.ENDS GJM1555C1H200GB01

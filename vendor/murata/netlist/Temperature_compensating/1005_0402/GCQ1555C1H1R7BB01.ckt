*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H1R7BB01
* Property : C = 1.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H1R7BB01 Port1 Port2
C01 Port1 N01 1.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.84e-10
R03 N02 N03 2.00e-01
C04 N03 N04 1.17e-10
L04 N03 N04 2.68e-12
R04 N03 N04 4.08e-01
C05 N04 Port2 1.34e-11
L05 N04 Port2 2.18e-11
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H1R7BB01

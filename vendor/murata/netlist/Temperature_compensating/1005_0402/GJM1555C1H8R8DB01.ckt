*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.80e-06[uF]/50[V]
* Murata P/N :GJM1555C1H8R8DB01
* Property : C = 8.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H8R8DB01 Port1 Port2
C01 Port1 N01 8.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 8.00e-02
L04 N03 N04 7.75e-11
R04 N03 N04 2.94e+01
C05 N04 N05 3.91e-11
L05 N04 N05 1.12e-11
R05 N04 N05 1.40e+01
C06 N05 Port2 2.66e-12
L06 N05 Port2 9.96e-11
R06 N05 Port2 1.00e+05
.ENDS GJM1555C1H8R8DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-06[uF]/200[V]
* Murata P/N :GQM1555C2D4R7CB01
* Property : C = 4.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D4R7CB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 1.03e-01
L04 N03 N04 5.79e-12
R04 N03 N04 5.21e-02
C05 N04 Port2 6.16e-12
L05 N04 Port2 5.23e-11
R05 N04 Port2 1.33e+02
.ENDS GQM1555C2D4R7CB01

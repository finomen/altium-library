*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-06[uF]/200[V]
* Murata P/N :GQM1555C2D2R0BB01
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D2R0BB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.65e-10
R03 N02 N03 1.20e-01
L04 N03 N04 3.23e-12
R04 N03 N04 4.08e-02
C05 N04 Port2 8.52e-11
L05 N04 Port2 3.54e-12
R05 N04 Port2 1.65e+00
.ENDS GQM1555C2D2R0BB01

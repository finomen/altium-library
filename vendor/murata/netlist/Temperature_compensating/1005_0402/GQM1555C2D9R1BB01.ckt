*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.10e-06[uF]/200[V]
* Murata P/N :GQM1555C2D9R1BB01
* Property : C = 9.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D9R1BB01 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 9.85e-11
R03 N02 N03 7.73e-02
L04 N03 N04 5.77e-12
R04 N03 N04 2.78e-02
C05 N04 N05 2.23e-11
L05 N04 N05 2.58e-11
R05 N04 N05 3.45e+01
C06 N05 Port2 1.97e-12
L06 N05 Port2 1.30e-10
R06 N05 Port2 3.35e+02
.ENDS GQM1555C2D9R1BB01

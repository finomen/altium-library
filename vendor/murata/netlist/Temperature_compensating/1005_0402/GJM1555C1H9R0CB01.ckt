*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GJM1555C1H9R0CB01
* Property : C = 9.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H9R0CB01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.07e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.42e-12
R04 N03 N04 1.47e-01
L05 N04 N05 3.63e-12
R05 N04 N05 1.32e-01
C06 N05 N06 2.39e-11
L06 N05 N06 1.89e-11
R06 N05 N06 2.02e+01
C07 N06 Port2 1.41e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GJM1555C1H9R0CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.50e-06[uF]/50[V]
* Murata P/N :GJM1555C1H8R5WB01
* Property : C = 8.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H8R5WB01 Port1 Port2
C01 Port1 N01 8.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 1.06e-11
R04 N03 N04 4.52e-01
C05 N04 N05 3.70e-11
L05 N04 N05 1.20e-11
R05 N04 N05 1.37e+01
C06 N05 Port2 2.92e-12
L06 N05 Port2 8.84e-11
R06 N05 Port2 4.08e+02
.ENDS GJM1555C1H8R5WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.40e-06[uF]/50[V]
* Murata P/N :GJM1555C1H7R4DB01
* Property : C = 7.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H7R4DB01 Port1 Port2
C01 Port1 N01 7.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.14e-10
R03 N02 N03 8.00e-02
L04 N03 N04 2.51e-11
R04 N03 N04 6.04e+00
L05 N04 N05 5.27e-12
R05 N04 N05 1.83e-01
C06 N05 N06 1.62e-11
L06 N05 N06 2.23e-11
R06 N05 N06 2.43e+01
C07 N06 Port2 1.83e-12
L07 N06 Port2 1.56e-10
R07 N06 Port2 1.00e+05
.ENDS GJM1555C1H7R4DB01

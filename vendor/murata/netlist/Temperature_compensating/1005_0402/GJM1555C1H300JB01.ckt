*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/50[V]
* Murata P/N :GJM1555C1H300JB01
* Property : C = 3.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.75e-10
R03 N02 N03 7.20e-02
C04 N03 N04 1.65e-10
L04 N03 N04 1.04e-11
R04 N03 N04 6.07e+00
C05 N04 N05 3.18e-11
L05 N04 N05 2.15e-11
R05 N04 N05 1.89e+01
C06 N05 N06 2.39e-11
L06 N05 N06 1.30e-11
R06 N05 N06 5.68e+00
C07 N06 Port2 3.34e-12
L07 N06 Port2 7.94e-11
R07 N06 Port2 1.00e+05
.ENDS GJM1555C1H300JB01

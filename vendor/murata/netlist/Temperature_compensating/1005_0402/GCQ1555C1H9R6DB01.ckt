*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.60e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H9R6DB01
* Property : C = 9.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H9R6DB01 Port1 Port2
C01 Port1 N01 9.60e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.41e-10
R03 N02 N03 7.18e-02
L04 N03 N04 5.26e-11
R04 N03 N04 2.13e+01
C05 N04 N05 4.39e-11
L05 N04 N05 1.21e-11
R05 N04 N05 1.28e+01
C06 N05 Port2 2.21e-12
L06 N05 Port2 1.05e-10
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H9R6DB01

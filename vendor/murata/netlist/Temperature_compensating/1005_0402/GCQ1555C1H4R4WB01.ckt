*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.40e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H4R4WB01
* Property : C = 4.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H4R4WB01 Port1 Port2
C01 Port1 N01 4.40e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.85e-10
R03 N02 N03 1.19e-01
L04 N03 N04 5.14e-12
R04 N03 N04 1.04e-01
C05 N04 N05 8.98e-11
L05 N04 N05 3.99e-12
R05 N04 N05 8.33e-01
C06 N05 Port2 8.10e-12
L06 N05 Port2 3.53e-11
R06 N05 Port2 1.00e+05
.ENDS GCQ1555C1H4R4WB01

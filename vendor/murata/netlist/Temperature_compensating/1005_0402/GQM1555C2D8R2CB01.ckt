*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.20e-06[uF]/200[V]
* Murata P/N :GQM1555C2D8R2CB01
* Property : C = 8.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D8R2CB01 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 7.06e-02
L04 N03 N04 3.73e-12
R04 N03 N04 8.84e-02
C05 N04 N05 2.15e-11
L05 N04 N05 2.39e-11
R05 N04 N05 3.13e+01
C06 N05 Port2 5.39e-12
L06 N05 Port2 5.40e-11
R06 N05 Port2 9.53e+01
.ENDS GQM1555C2D8R2CB01

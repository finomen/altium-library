*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR90BB01
* Property : C = 9.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 2.53e-01
C04 N03 N04 4.19e-12
L04 N03 N04 1.65e-11
R04 N03 N04 7.26e+01
C05 N04 N05 3.13e-12
L05 N04 N05 1.73e-11
R05 N04 N05 1.05e+02
C06 N05 Port2 1.85e-13
L06 N05 Port2 1.24e-10
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR90BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-06[uF]/200[V]
* Murata P/N :GQM1555C2D1R5CB01
* Property : C = 1.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D1R5CB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.59e-10
R03 N02 N03 1.32e-01
L04 N03 N04 3.98e-12
R04 N03 N04 3.37e-02
C05 N04 Port2 1.59e-10
L05 N04 Port2 2.00e-12
R05 N04 Port2 1.44e+00
.ENDS GQM1555C2D1R5CB01

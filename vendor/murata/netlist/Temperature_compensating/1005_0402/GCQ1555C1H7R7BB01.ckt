*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.70e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R7BB01
* Property : C = 7.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R7BB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.44e-10
R03 N02 N03 8.00e-02
L04 N03 N04 9.29e-12
R04 N03 N04 7.13e-01
L05 N04 N05 5.22e-12
R05 N04 N05 7.56e-02
C06 N05 N06 3.40e-11
L06 N05 N06 1.19e-11
R06 N05 N06 1.42e+01
C07 N06 Port2 4.03e-12
L07 N06 Port2 6.66e-11
R07 N06 Port2 1.00e+05
.ENDS GCQ1555C1H7R7BB01

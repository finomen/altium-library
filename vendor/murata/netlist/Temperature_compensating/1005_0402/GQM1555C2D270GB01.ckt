*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-05[uF]/200[V]
* Murata P/N :GQM1555C2D270GB01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D270GB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.03e-10
R03 N02 N03 8.28e-02
C04 N03 N04 9.36e-11
L04 N03 N04 1.77e-11
R04 N03 N04 9.60e+00
C05 N04 N05 3.36e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.40e+01
C06 N05 N06 3.97e-11
L06 N05 N06 8.89e-12
R06 N05 N06 7.08e+00
C07 N06 Port2 1.45e-11
L07 N06 Port2 2.04e-11
R07 N06 Port2 6.92e+01
.ENDS GQM1555C2D270GB01

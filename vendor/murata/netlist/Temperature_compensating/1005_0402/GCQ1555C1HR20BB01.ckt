*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR20BB01
* Property : C = 2.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR20BB01 Port1 Port2
C01 Port1 N01 2.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.37e-10
R03 N02 N03 4.75e-01
C04 N03 N04 3.94e-12
L04 N03 N04 1.30e-11
R04 N03 N04 1.00e+08
C05 N04 Port2 8.88e-12
L05 N04 Port2 5.18e-12
R05 N04 Port2 1.24e+01
.ENDS GCQ1555C1HR20BB01

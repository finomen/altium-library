*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D300JB01
* Property : C = 3.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D300JB01 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.71e-10
R03 N02 N03 8.20e-02
C04 N03 N04 1.02e-10
L04 N03 N04 1.82e-11
R04 N03 N04 1.22e+01
C05 N04 N05 3.87e-11
L05 N04 N05 2.00e-11
R05 N04 N05 1.80e+01
C06 N05 N06 4.21e-11
L06 N05 N06 9.31e-12
R06 N05 N06 1.02e+01
C07 N06 Port2 5.79e-12
L07 N06 Port2 5.00e-11
R07 N06 Port2 1.74e+02
.ENDS GQM1555C2D300JB01

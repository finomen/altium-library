*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H9R0DE01
* Property : C = 9.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H9R0DE01 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.00e-10
R03 N02 N03 1.11e-01
L04 N03 N04 3.73e-11
R04 N03 N04 2.69e+00
L05 N04 N05 4.27e-11
R05 N04 N05 1.72e-01
C06 N05 Port2 5.11e-10
L06 N05 Port2 1.54e-12
R06 N05 Port2 3.68e-01
.ENDS GCH1555C1H9R0DE01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.10e-05[uF]/50[V]
* Murata P/N :GJM1555C1H110JB01
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H110JB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.81e-10
R03 N02 N03 7.91e-02
L04 N03 N04 5.59e-12
R04 N03 N04 9.79e-02
C05 N04 N05 4.47e-11
L05 N04 N05 1.39e-11
R05 N04 N05 1.37e+01
C06 N05 N06 4.59e-12
L06 N05 N06 5.35e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 4.22e-12
L07 N06 Port2 4.95e-11
R07 N06 Port2 7.37e+01
.ENDS GJM1555C1H110JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR40WB01
* Property : C = 4.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR40WB01 Port1 Port2
C01 Port1 N01 4.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 3.47e-10
R03 N02 N03 3.46e-01
C04 N03 Port2 2.61e-12
L04 N03 Port2 1.96e-11
R04 N03 Port2 3.43e+01
.ENDS GCQ1555C1HR40WB01

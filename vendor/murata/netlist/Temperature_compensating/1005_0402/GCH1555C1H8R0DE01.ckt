*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-06[uF]/50[V]
* Murata P/N :GCH1555C1H8R0DE01
* Property : C = 8.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCH1555C1H8R0DE01 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.21e-10
R03 N02 N03 9.47e-02
L04 N03 N04 2.38e-11
R04 N03 N04 4.47e-01
L05 N04 N05 3.68e-11
R05 N04 N05 8.92e-02
C06 N05 N06 1.47e-10
L06 N05 N06 4.58e-12
R06 N05 N06 1.16e+00
C07 N06 Port2 2.73e-10
L07 N06 Port2 1.27e-12
R07 N06 Port2 2.75e-01
.ENDS GCH1555C1H8R0DE01

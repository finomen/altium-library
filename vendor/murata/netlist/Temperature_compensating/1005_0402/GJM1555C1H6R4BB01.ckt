*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.40e-06[uF]/50[V]
* Murata P/N :GJM1555C1H6R4BB01
* Property : C = 6.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H6R4BB01 Port1 Port2
C01 Port1 N01 6.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.71e-10
R03 N02 N03 9.31e-02
L04 N03 N04 5.87e-11
R04 N03 N04 1.98e+01
C05 N04 Port2 1.76e-11
L05 N04 Port2 1.44e-11
R05 N04 Port2 6.32e+00
.ENDS GJM1555C1H6R4BB01

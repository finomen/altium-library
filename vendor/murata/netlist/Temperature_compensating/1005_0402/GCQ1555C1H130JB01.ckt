*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.30e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H130JB01
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 9.24e-11
R03 N02 N03 7.89e-02
L04 N03 N04 7.37e-12
R04 N03 N04 4.70e-01
L05 N04 N05 9.88e-12
R05 N04 N05 2.73e-02
C06 N05 N06 5.73e-11
L06 N05 N06 1.17e-11
R06 N05 N06 1.19e+01
C07 N06 N07 5.31e-12
L07 N06 N07 5.07e-11
R07 N06 N07 7.90e+01
C08 N07 Port2 1.53e-12
L08 N07 Port2 1.59e-10
R08 N07 Port2 1.00e+05
.ENDS GCQ1555C1H130JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR10BB01
* Property : C = 1.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR10BB01 Port1 Port2
C01 Port1 N01 1.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 5.30e-10
R03 N02 N03 6.04e-01
C04 N03 Port2 3.22e-10
L04 N03 Port2 1.89e-13
R04 N03 Port2 1.44e-01
.ENDS GQM1555C2DR10BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.20e-05[uF]/200[V]
* Murata P/N :GQM1555C2D220GB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.02e-10
R03 N02 N03 8.45e-02
C04 N03 N04 8.55e-11
L04 N03 N04 1.55e-11
R04 N03 N04 9.39e+00
C05 N04 N05 2.76e-11
L05 N04 N05 2.05e-11
R05 N04 N05 1.48e+01
C06 N05 Port2 1.59e-11
L06 N05 Port2 1.97e-11
R06 N05 Port2 2.00e+01
.ENDS GQM1555C2D220GB01

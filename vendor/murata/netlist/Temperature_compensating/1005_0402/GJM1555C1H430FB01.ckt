*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.30e-05[uF]/50[V]
* Murata P/N :GJM1555C1H430FB01
* Property : C = 4.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H430FB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.47e-11
R03 N02 N03 7.00e-02
C04 N03 N04 2.01e-10
L04 N03 N04 1.32e-11
R04 N03 N04 5.74e+00
C05 N04 N05 5.95e-11
L05 N04 N05 1.87e-11
R05 N04 N05 1.38e+01
C06 N05 N06 1.52e-10
L06 N05 N06 3.67e-12
R06 N05 N06 2.95e+00
C07 N06 N07 2.90e-11
L07 N06 N07 1.18e-11
R07 N06 N07 1.15e+01
C08 N07 Port2 1.22e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.00e+05
.ENDS GJM1555C1H430FB01

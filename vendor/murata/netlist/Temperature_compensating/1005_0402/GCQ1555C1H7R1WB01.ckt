*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/7.10e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H7R1WB01
* Property : C = 7.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H7R1WB01 Port1 Port2
C01 Port1 N01 7.10e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 2.89e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.93e-11
R04 N03 N04 1.10e+01
C05 N04 Port2 6.32e-11
L05 N04 Port2 5.35e-12
R05 N04 Port2 2.15e+00
.ENDS GCQ1555C1H7R1WB01

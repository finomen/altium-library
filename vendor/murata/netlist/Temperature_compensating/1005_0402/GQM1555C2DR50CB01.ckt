*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR50CB01
* Property : C = 5.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR50CB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.56e-10
R03 N02 N03 3.24e-01
C04 N03 N04 3.66e-11
L04 N03 N04 1.61e-12
R04 N03 N04 1.21e+00
C05 N04 Port2 7.77e-13
L05 N04 Port2 5.87e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR50CB01

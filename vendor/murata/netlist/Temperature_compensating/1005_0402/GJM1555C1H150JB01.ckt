*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-05[uF]/50[V]
* Murata P/N :GJM1555C1H150JB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.36e-11
R03 N02 N03 7.92e-02
L04 N03 N04 3.95e-12
R04 N03 N04 8.90e-02
C05 N04 N05 7.22e-11
L05 N04 N05 1.17e-11
R05 N04 N05 1.08e+01
C06 N05 N06 7.71e-12
L06 N05 N06 4.36e-11
R06 N05 N06 5.51e+01
C07 N06 Port2 6.98e-13
L07 N06 Port2 2.14e-10
R07 N06 Port2 1.00e+05
.ENDS GJM1555C1H150JB01

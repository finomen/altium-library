*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/8.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR80CB01
* Property : C = 8.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR80CB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.15e-10
R03 N02 N03 2.75e-01
C04 N03 N04 4.78e-12
L04 N03 N04 1.40e-11
R04 N03 N04 6.17e+01
C05 N04 N05 3.43e-11
L05 N04 N05 1.59e-12
R05 N04 N05 2.04e+01
C06 N05 Port2 5.29e-13
L06 N05 Port2 8.27e-11
R06 N05 Port2 1.00e+08
.ENDS GQM1555C2DR80CB01

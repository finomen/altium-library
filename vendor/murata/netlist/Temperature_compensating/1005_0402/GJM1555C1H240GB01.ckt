*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.40e-05[uF]/50[V]
* Murata P/N :GJM1555C1H240GB01
* Property : C = 2.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.35e-10
R03 N02 N03 7.50e-02
C04 N03 N04 1.08e-10
L04 N03 N04 1.15e-11
R04 N03 N04 5.34e+00
C05 N04 N05 1.45e-11
L05 N04 N05 3.32e-11
R05 N04 N05 2.56e+01
C06 N05 Port2 1.67e-12
L06 N05 Port2 1.37e-10
R06 N05 Port2 1.00e+05
.ENDS GJM1555C1H240GB01

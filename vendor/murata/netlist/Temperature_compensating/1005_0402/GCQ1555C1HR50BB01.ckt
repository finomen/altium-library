*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.00e-07[uF]/50[V]
* Murata P/N :GCQ1555C1HR50BB01
* Property : C = 5.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1HR50BB01 Port1 Port2
C01 Port1 N01 5.00e-13
R01 Port1 N01 1.00e+11
L02 N01 N02 1.57e-10
R03 N02 N03 3.28e-01
C04 N03 N04 1.22e-11
L04 N03 N04 4.38e-12
R04 N03 N04 4.42e+00
C05 N04 Port2 1.60e-13
L05 N04 Port2 1.67e-10
R05 N04 Port2 1.00e+08
.ENDS GCQ1555C1HR50BB01

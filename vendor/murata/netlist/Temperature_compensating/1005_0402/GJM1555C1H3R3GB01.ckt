*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-06[uF]/50[V]
* Murata P/N :GJM1555C1H3R3GB01
* Property : C = 3.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H3R3GB01 Port1 Port2
C01 Port1 N01 3.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-10
R03 N02 N03 1.30e-01
C04 N03 N04 3.54e-12
L04 N03 N04 7.36e-11
R04 N03 N04 1.00e+05
C05 N04 Port2 2.02e-11
L05 N04 Port2 1.16e-11
R05 N04 Port2 1.67e+00
.ENDS GJM1555C1H3R3GB01

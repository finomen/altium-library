*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.90e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H6R9BB01
* Property : C = 6.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H6R9BB01 Port1 Port2
C01 Port1 N01 6.90e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 3.12e-10
R03 N02 N03 8.07e-02
L04 N03 N04 7.64e-12
R04 N03 N04 1.23e-01
C05 N04 Port2 9.18e-12
L05 N04 Port2 2.70e-11
R05 N04 Port2 1.96e+01
.ENDS GCQ1555C1H6R9BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/4.70e-05[uF]/50[V]
* Murata P/N :GJM1555C1H470FB01
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H470FB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.12e-10
R03 N02 N03 7.00e-02
C04 N03 N04 2.11e-10
L04 N03 N04 1.40e-11
R04 N03 N04 6.28e+00
C05 N04 N05 6.55e-11
L05 N04 N05 1.92e-11
R05 N04 N05 1.07e+01
C06 N05 N06 1.62e-10
L06 N05 N06 3.88e-12
R06 N05 N06 2.58e+00
C07 N06 N07 4.76e-11
L07 N06 N07 8.30e-12
R07 N06 N07 7.40e+00
C08 N07 Port2 1.15e-11
L08 N07 Port2 2.42e-11
R08 N07 Port2 1.00e+05
.ENDS GJM1555C1H470FB01

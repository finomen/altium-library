*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.00e-05[uF]/200[V]
* Murata P/N :GQM1555C2D100JB01
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2D100JB01 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 1.07e-01
C04 N03 N04 3.15e-11
L04 N03 N04 2.00e-11
R04 N03 N04 2.49e+01
C05 N04 Port2 9.28e-12
L05 N04 Port2 3.41e-11
R05 N04 Port2 7.73e+01
.ENDS GQM1555C2D100JB01

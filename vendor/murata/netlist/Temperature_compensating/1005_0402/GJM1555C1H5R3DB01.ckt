*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/5.30e-06[uF]/50[V]
* Murata P/N :GJM1555C1H5R3DB01
* Property : C = 5.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H5R3DB01 Port1 Port2
C01 Port1 N01 5.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.42e-10
R03 N02 N03 1.00e-01
L04 N03 N04 7.42e-12
R04 N03 N04 1.13e-01
C05 N04 N05 1.77e-10
L05 N04 N05 2.73e-12
R05 N04 N05 3.27e-01
C06 N05 Port2 2.45e-12
L06 N05 Port2 8.47e-11
R06 N05 Port2 1.00e+05
.ENDS GJM1555C1H5R3DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.30e-05[uF]/50[V]
* Murata P/N :GJM1555C1H330JB01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 7.10e-02
C04 N03 N04 1.29e-10
L04 N03 N04 1.55e-11
R04 N03 N04 5.64e+00
C05 N04 N05 4.28e-11
L05 N04 N05 1.89e-11
R05 N04 N05 1.46e+01
C06 N05 N06 1.11e-10
L06 N05 N06 3.58e-12
R06 N05 N06 3.06e+00
C07 N06 Port2 8.90e-12
L07 N06 Port2 3.12e-11
R07 N06 Port2 1.00e+05
.ENDS GJM1555C1H330JB01

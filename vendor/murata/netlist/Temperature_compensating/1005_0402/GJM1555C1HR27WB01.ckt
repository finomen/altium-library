*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/2.70e-07[uF]/50[V]
* Murata P/N :GJM1555C1HR27WB01
* Property : C = 2.70e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1HR27WB01 Port1 Port2
C01 Port1 N01 2.70e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 3.76e-10
R03 N02 N03 4.11e-01
C04 N03 Port2 4.29e-11
L04 N03 Port2 1.31e-12
R04 N03 Port2 8.57e-01
.ENDS GJM1555C1HR27WB01

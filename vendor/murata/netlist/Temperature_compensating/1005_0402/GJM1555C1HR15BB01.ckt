*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.50e-07[uF]/50[V]
* Murata P/N :GJM1555C1HR15BB01
* Property : C = 1.50e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1HR15BB01 Port1 Port2
C01 Port1 N01 1.50e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 4.35e-10
R03 N02 N03 5.37e-01
C04 N03 Port2 1.21e-10
L04 N03 Port2 4.61e-13
R04 N03 Port2 5.01e-01
.ENDS GJM1555C1HR15BB01

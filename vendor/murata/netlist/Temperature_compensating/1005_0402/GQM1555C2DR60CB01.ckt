*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/6.00e-07[uF]/200[V]
* Murata P/N :GQM1555C2DR60CB01
* Property : C = 6.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1555C2DR60CB01 Port1 Port2
C01 Port1 N01 6.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.04e-10
R03 N02 N03 3.08e-01
C04 N03 N04 4.78e-11
L04 N03 N04 1.28e-12
R04 N03 N04 9.02e-01
C05 N04 Port2 5.48e-13
L05 N04 Port2 7.50e-11
R05 N04 Port2 1.00e+08
.ENDS GQM1555C2DR60CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/9.00e-07[uF]/50[V]
* Murata P/N :GJM1555C1HR90BB01
* Property : C = 9.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-20[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM1555C1HR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 2.87e-10
R03 N02 N03 2.52e-01
C04 N03 Port2 5.82e-13
L04 N03 Port2 9.54e-11
R04 N03 Port2 3.53e+02
.ENDS GJM1555C1HR90BB01

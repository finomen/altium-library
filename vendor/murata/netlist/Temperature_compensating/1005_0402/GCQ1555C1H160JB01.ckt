*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/1.60e-05[uF]/50[V]
* Murata P/N :GCQ1555C1H160JB01
* Property : C = 1.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+11
L02 N01 N02 2.41e-10
R03 N02 N03 7.35e-02
L04 N03 N04 7.87e-12
R04 N03 N04 2.84e-02
C05 N04 N05 7.02e-11
L05 N04 N05 1.28e-11
R05 N04 N05 1.04e+01
C06 N05 Port2 7.18e-12
L06 N05 Port2 5.20e-11
R06 N05 Port2 6.84e+01
.ENDS GCQ1555C1H160JB01

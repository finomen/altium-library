*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/C0G(-55to125[deg])/3.80e-06[uF]/50[V]
* Murata P/N :GCQ1555C1H3R8CB01
* Property : C = 3.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCQ1555C1H3R8CB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+11
L02 N01 N02 1.74e-10
R03 N02 N03 1.20e-01
C04 N03 N04 3.91e-11
L04 N03 N04 8.18e-12
R04 N03 N04 6.76e-01
C05 N04 Port2 1.65e-12
L05 N04 Port2 1.31e-10
R05 N04 Port2 1.00e+05
.ENDS GCQ1555C1H3R8CB01

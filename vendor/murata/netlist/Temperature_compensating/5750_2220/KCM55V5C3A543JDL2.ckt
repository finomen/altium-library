*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/5.40e-02[uF]/1000[V]
* Murata P/N :KCM55V5C3A543JDL2
* Property : C = 5.40e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55V5C3A543JDL2 Port1 Port2
C01 Port1 N01 5.23e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 9.98e-11
R03 N02 N03 2.99e-03
C04 N03 N04 3.57e-05
R04 N03 N04 7.82e-02
L05 N04 N05 7.55e-11
R05 N04 N05 1.71e+00
L06 N05 N06 1.73e-10
R06 N05 N06 2.01e-01
L07 N06 N07 1.81e-10
R07 N06 N07 5.79e-03
C08 N07 N08 1.12e-07
L08 N07 N08 2.53e-10
R08 N07 N08 8.87e-01
C09 N08 N09 1.12e-07
L09 N08 N09 7.64e-11
R09 N08 N09 3.30e-01
C10 N09 N10 1.31e-07
L10 N09 N10 4.50e-11
R10 N09 N10 2.03e-01
C11 N10 N11 4.87e-08
L11 N10 N11 5.53e-11
R11 N10 N11 2.23e-01
C12 N11 N12 7.04e-08
L12 N11 N12 1.92e-11
R12 N11 N12 9.51e-02
C13 N12 N13 5.22e-08
L13 N12 N13 1.49e-11
R13 N12 N13 7.05e-02
C14 N13 Port2 2.87e-12
L14 N13 Port2 1.08e-09
R14 N13 Port2 7.05e+02
.ENDS KCM55V5C3A543JDL2

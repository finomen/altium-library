*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/3.90e-02[uF]/630[V]
* Murata P/N :KCM55L7U2J393JDL1
* Property : C = 3.90e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55L7U2J393JDL1 Port1 Port2
C01 Port1 N01 3.76e-08
R01 Port1 N01 2.56e+09
L02 N01 N02 1.77e-11
R03 N02 N03 2.23e-03
C04 N03 N04 1.67e-05
R04 N03 N04 1.46e-01
L05 N04 N05 1.34e-10
R05 N04 N05 1.79e-01
L06 N05 N06 3.79e-13
R06 N05 N06 6.81e-03
L07 N06 N07 1.99e-11
R07 N06 N07 3.66e-03
L08 N07 N08 1.07e-10
R08 N07 N08 3.34e-03
C09 N08 N09 9.46e-08
L09 N08 N09 9.00e-11
R09 N08 N09 3.82e-01
C10 N09 N10 3.51e-08
L10 N09 N10 8.40e-11
R10 N09 N10 3.82e-01
C11 N10 N11 1.16e-07
L11 N10 N11 1.11e-11
R11 N10 N11 6.05e-02
C12 N11 N12 4.74e-08
L12 N11 N12 1.64e-11
R12 N11 N12 1.15e-01
C13 N12 Port2 2.79e-12
L13 N12 Port2 1.21e-09
R13 N12 Port2 8.16e+02
.ENDS KCM55L7U2J393JDL1

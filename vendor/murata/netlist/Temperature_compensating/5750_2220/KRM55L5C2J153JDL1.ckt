*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/1.50e-02[uF]/630[V]
* Murata P/N :KRM55L5C2J153JDL1
* Property : C = 1.50e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55L5C2J153JDL1 Port1 Port2
C01 Port1 N01 1.49e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 2.14e-12
R03 N02 N03 6.60e-03
C04 N03 N04 2.29e-06
R04 N03 N04 2.43e+00
C05 N04 N05 2.51e-04
R05 N04 N05 2.21e-03
L06 N05 N06 9.56e-11
R06 N05 N06 4.03e-01
L07 N06 N07 4.08e-11
R07 N06 N07 2.92e-02
L08 N07 N08 1.18e-10
R08 N07 N08 9.45e-03
C09 N08 N09 4.93e-08
L09 N08 N09 5.72e-11
R09 N08 N09 3.22e-01
C10 N09 N10 1.46e-08
L10 N09 N10 6.72e-11
R10 N09 N10 4.45e-01
C11 N10 N11 1.39e-08
L11 N10 N11 1.85e-11
R11 N10 N11 1.38e-01
C12 N11 N12 2.47e-11
L12 N11 N12 1.50e-10
R12 N11 N12 1.47e+01
C13 N12 Port2 2.84e-12
L13 N12 Port2 1.19e-09
R13 N12 Port2 4.45e+03
.ENDS KRM55L5C2J153JDL1

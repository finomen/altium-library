*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/2.20e-02[uF]/1000[V]
* Murata P/N :KCM55R5C3A223JDL1
* Property : C = 2.20e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55R5C3A223JDL1 Port1 Port2
C01 Port1 N01 2.14e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-10
R03 N02 N03 4.57e-03
C04 N03 N04 6.29e-06
R04 N03 N04 5.58e-01
L05 N04 N05 1.38e-10
R05 N04 N05 1.89e-01
L06 N05 N06 1.35e-11
R06 N05 N06 1.22e-01
L07 N06 N07 2.35e-11
R07 N06 N07 1.34e-02
L08 N07 N08 1.83e-10
R08 N07 N08 9.04e-03
C09 N08 N09 7.17e-08
L09 N08 N09 7.49e-11
R09 N08 N09 3.44e-01
C10 N09 N10 2.73e-08
L10 N09 N10 7.49e-11
R10 N09 N10 4.23e-01
C11 N10 N11 1.16e-07
L11 N10 N11 8.03e-12
R11 N10 N11 5.70e-02
C12 N11 N12 4.32e-08
L12 N11 N12 1.36e-11
R12 N11 N12 1.22e-01
C13 N12 Port2 2.52e-12
L13 N12 Port2 1.30e-09
R13 N12 Port2 1.29e+03
.ENDS KCM55R5C3A223JDL1

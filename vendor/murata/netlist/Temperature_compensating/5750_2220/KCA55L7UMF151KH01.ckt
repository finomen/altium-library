*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.50e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF151KH01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF151KH01 Port1 Port2
C01 Port1 N01 1.50e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-12
R03 N02 N03 2.85e-04
L04 N03 N04 1.07e-10
R04 N03 N04 6.96e-02
C05 N04 N05 8.81e-09
L05 N04 N05 3.00e-11
R05 N04 N05 6.44e-02
C06 N05 N06 1.41e-10
L06 N05 N06 6.83e-11
R06 N05 N06 6.37e+00
C07 N06 N07 2.85e-12
L07 N06 N07 1.59e-09
R07 N06 N07 4.98e+02
C08 N07 Port2 4.16e-11
L08 N07 Port2 6.56e-11
R08 N07 Port2 8.09e+00
.ENDS KCA55L7UMF151KH01

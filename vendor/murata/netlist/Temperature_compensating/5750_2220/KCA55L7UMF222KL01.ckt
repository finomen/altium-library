*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/2.20e-03[uF]/250[Vac]
* Murata P/N :KCA55L7UMF222KL01
* Property : C = 2.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF222KL01 Port1 Port2
C01 Port1 N01 2.43e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 2.72e-11
R03 N02 N03 8.84e-03
C04 N03 N04 1.91e-08
R04 N03 N04 6.88e+02
C05 N04 N05 2.09e-05
R05 N04 N05 2.24e-02
C06 N05 N06 1.11e-04
R06 N05 N06 8.16e-04
L07 N06 N07 1.24e-10
R07 N06 N07 9.99e-02
L08 N07 N08 2.06e-10
R08 N07 N08 1.69e-02
C09 N08 N09 7.77e-09
L09 N08 N09 4.88e-11
R09 N08 N09 9.45e-01
C10 N09 N10 1.72e-09
L10 N09 N10 6.76e-11
R10 N09 N10 1.41e+00
C11 N10 N11 3.58e-09
L11 N10 N11 1.43e-11
R11 N10 N11 3.04e-01
C12 N11 N12 1.14e-09
L12 N11 N12 2.59e-11
R12 N11 N12 7.38e-01
C13 N12 Port2 2.69e-12
L13 N12 Port2 1.48e-09
R13 N12 Port2 4.00e+02
.ENDS KCA55L7UMF222KL01

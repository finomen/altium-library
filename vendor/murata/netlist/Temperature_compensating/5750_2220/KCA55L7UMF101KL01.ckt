*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.00e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF101KL01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF101KL01 Port1 Port2
C01 Port1 N01 1.08e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 7.03e-13
R03 N02 N03 1.58e-03
C04 N03 N04 2.76e-10
R04 N03 N04 1.67e-03
L05 N04 N05 1.23e-10
R05 N04 N05 1.70e-01
L06 N05 N06 1.09e-12
R06 N05 N06 8.48e-03
L07 N06 N07 3.36e-13
R07 N06 N07 3.90e-03
C08 N07 N08 6.30e-12
L08 N07 N08 7.98e-10
R08 N07 N08 1.67e+02
C09 N08 N09 5.60e-12
L09 N08 N09 7.84e-10
R09 N08 N09 2.80e+02
C10 N09 N10 2.76e-10
L10 N09 N10 4.64e-12
R10 N09 N10 1.03e+00
C11 N10 N11 4.81e-09
L11 N10 N11 1.64e-13
R11 N10 N11 8.72e-02
C12 N11 Port2 3.90e-10
L12 N11 Port2 1.40e-12
R12 N11 Port2 2.57e-01
.ENDS KCA55L7UMF101KL01

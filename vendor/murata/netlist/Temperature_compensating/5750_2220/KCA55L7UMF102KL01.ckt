*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.00e-03[uF]/250[Vac]
* Murata P/N :KCA55L7UMF102KL01
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF102KL01 Port1 Port2
C01 Port1 N01 1.00e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.41e-09
R03 N02 N03 6.74e-03
C04 N03 N04 4.80e-08
R04 N03 N04 2.21e+01
C05 N04 N05 1.97e-07
R05 N04 N05 1.20e+01
C06 N05 N06 5.13e-07
R06 N05 N06 1.12e+01
C07 N06 N07 9.90e-05
R07 N06 N07 9.97e-03
L08 N07 N08 2.07e-10
R08 N07 N08 6.22e-02
C09 N08 N09 3.05e-05
L09 N08 N09 5.04e-11
R09 N08 N09 2.18e-01
C10 N09 N10 2.71e-09
L10 N09 N10 4.70e-11
R10 N09 N10 1.11e+00
C11 N10 N11 6.52e-10
L11 N10 N11 5.72e-11
R11 N10 N11 1.86e+00
C12 N11 N12 4.93e-09
L12 N11 N12 3.34e-12
R12 N11 N12 2.67e-01
C13 N12 N13 7.85e-10
L13 N12 N13 1.20e-11
R13 N12 N13 6.29e-01
C14 N13 Port2 8.40e-12
L14 N13 Port2 1.55e-10
R14 N13 Port2 5.79e+00
.ENDS KCA55L7UMF102KL01

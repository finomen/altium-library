*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/8.20e-03[uF]/1000[V]
* Murata P/N :KCM55L7U3A822JDL1
* Property : C = 8.20e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55L7U3A822JDL1 Port1 Port2
C01 Port1 N01 8.20e-09
R01 Port1 N01 1.00e+11
L02 N01 N02 1.62e-12
R03 N02 N03 2.64e-03
C04 N03 N04 6.18e-07
R04 N03 N04 8.99e+00
C05 N04 N05 2.14e-05
R05 N04 N05 1.61e-02
L06 N05 N06 9.78e-11
R06 N05 N06 5.68e-01
L07 N06 N07 3.24e-11
R07 N06 N07 2.64e-02
L08 N07 N08 8.56e-11
R08 N07 N08 9.40e-03
C09 N08 N09 1.80e-08
L09 N08 N09 8.70e-11
R09 N08 N09 6.96e-01
C10 N09 N10 7.58e-09
L10 N09 N10 7.02e-11
R10 N09 N10 8.39e-01
C11 N10 N11 3.57e-08
L11 N10 N11 7.01e-12
R11 N10 N11 1.61e-01
C12 N11 N12 8.43e-09
L12 N11 N12 1.64e-11
R12 N11 N12 2.97e-01
C13 N12 Port2 2.92e-12
L13 N12 Port2 1.21e-09
R13 N12 Port2 8.65e+02
.ENDS KCM55L7U3A822JDL1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/2.20e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF221KH01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF221KH01 Port1 Port2
C01 Port1 N01 2.05e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-11
R03 N02 N03 8.03e-04
L04 N03 N04 1.17e-11
R04 N03 N04 1.38e-01
L05 N04 N05 1.33e-10
R05 N04 N05 7.38e-02
C06 N05 N06 9.19e-08
L06 N05 N06 4.77e-12
R06 N05 N06 2.53e-02
C07 N06 N07 5.08e-10
L07 N06 N07 4.10e-11
R07 N06 N07 3.28e+00
C08 N07 N08 2.27e-08
L08 N07 N08 5.44e-13
R08 N07 N08 3.31e-02
C09 N08 N09 1.89e-11
L09 N08 N09 3.16e-10
R09 N08 N09 3.11e+01
C10 N09 N10 4.76e-12
L10 N09 N10 8.46e-10
R10 N09 N10 2.17e+02
C11 N10 Port2 8.33e-12
L11 N10 Port2 4.69e-10
R11 N10 Port2 4.77e+02
.ENDS KCA55L7UMF221KH01

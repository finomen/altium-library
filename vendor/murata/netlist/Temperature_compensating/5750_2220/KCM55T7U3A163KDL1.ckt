*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.60e-02[uF]/1000[V]
* Murata P/N :KCM55T7U3A163KDL1
* Property : C = 1.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55T7U3A163KDL1 Port1 Port2
C01 Port1 N01 1.65e-08
R01 Port1 N01 6.25e+09
L02 N01 N02 8.23e-12
R03 N02 N03 2.27e-03
C04 N03 N04 2.89e-06
R04 N03 N04 1.78e+00
C05 N04 N05 2.24e-05
R05 N04 N05 5.26e-02
L06 N05 N06 1.10e-10
R06 N05 N06 6.43e-01
L07 N06 N07 5.95e-11
R07 N06 N07 4.00e-02
L08 N07 N08 8.80e-11
R08 N07 N08 6.49e-03
C09 N08 N09 3.33e-08
L09 N08 N09 2.05e-10
R09 N08 N09 1.57e+00
C10 N09 N10 2.36e-08
L10 N09 N10 7.62e-11
R10 N09 N10 6.68e-01
C11 N10 N11 3.33e-08
L11 N10 N11 3.40e-11
R11 N10 N11 3.85e-01
C12 N11 N12 2.20e-08
L12 N11 N12 2.51e-11
R12 N11 N12 3.89e-01
C13 N12 N13 2.86e-08
L13 N12 N13 1.54e-11
R13 N12 N13 2.43e-01
C14 N13 N14 2.09e-08
L14 N13 N14 1.15e-11
R14 N13 N14 2.06e-01
C15 N14 N15 1.82e-08
L15 N14 N15 7.74e-12
R15 N14 N15 1.42e-01
C16 N15 Port2 2.92e-12
L16 N15 Port2 1.13e-09
R16 N15 Port2 1.05e+03
.ENDS KCM55T7U3A163KDL1

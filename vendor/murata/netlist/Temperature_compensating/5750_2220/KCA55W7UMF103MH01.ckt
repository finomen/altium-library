*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.00e-02[uF]/250[Vac]
* Murata P/N :KCA55W7UMF103MH01
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55W7UMF103MH01 Port1 Port2
C01 Port1 N01 9.42e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.13e-11
R03 N02 N03 1.93e-03
C04 N03 N04 7.55e-07
R04 N03 N04 7.89e+00
C05 N04 N05 1.47e-05
R05 N04 N05 5.24e-03
L06 N05 N06 1.36e-10
R06 N05 N06 9.27e-01
L07 N06 N07 1.79e-10
R07 N06 N07 2.38e-02
L08 N07 N08 1.23e-09
R08 N07 N08 1.61e-02
C09 N08 N09 1.48e-08
L09 N08 N09 3.43e-10
R09 N08 N09 2.43e+00
C10 N09 N10 1.29e-08
L10 N09 N10 1.19e-10
R10 N09 N10 9.77e-01
C11 N10 N11 1.86e-08
L11 N10 N11 5.09e-11
R11 N10 N11 6.05e-01
C12 N11 N12 1.09e-08
L12 N11 N12 4.58e-11
R12 N11 N12 6.39e-01
C13 N12 N13 2.03e-08
L13 N12 N13 1.89e-11
R13 N12 N13 3.41e-01
C14 N13 N14 7.64e-09
L14 N13 N14 2.97e-11
R14 N13 N14 3.55e-01
C15 N14 N15 7.67e-09
L15 N14 N15 1.72e-11
R15 N14 N15 3.40e-01
C16 N15 N16 1.34e-08
L16 N15 N16 6.41e-12
R16 N15 N16 1.68e-01
C17 N16 N17 5.92e-09
L17 N16 N17 9.78e-12
R17 N16 N17 1.61e-01
C18 N17 Port2 2.57e-12
L18 N17 Port2 1.22e-09
R18 N17 Port2 7.61e+02
.ENDS KCA55W7UMF103MH01

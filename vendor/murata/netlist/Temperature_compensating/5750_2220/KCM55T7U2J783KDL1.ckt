*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/7.80e-02[uF]/630[V]
* Murata P/N :KCM55T7U2J783KDL1
* Property : C = 7.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55T7U2J783KDL1 Port1 Port2
C01 Port1 N01 7.67e-08
R01 Port1 N01 1.28e+09
L02 N01 N02 8.35e-12
R03 N02 N03 1.88e-03
C04 N03 N04 1.33e-05
R04 N03 N04 7.76e-01
L05 N04 N05 1.22e-10
R05 N04 N05 1.61e-01
L06 N05 N06 4.53e-11
R06 N05 N06 4.24e-03
L07 N06 N07 1.07e-10
R07 N06 N07 2.16e-03
C08 N07 N08 1.38e-07
L08 N07 N08 2.45e-10
R08 N07 N08 7.51e-01
C09 N08 N09 1.06e-07
L09 N08 N09 8.93e-11
R09 N08 N09 3.99e-01
C10 N09 N10 1.55e-07
L10 N09 N10 3.95e-11
R10 N09 N10 1.61e-01
C11 N10 N11 7.11e-08
L11 N10 N11 4.15e-11
R11 N10 N11 1.68e-01
C12 N11 N12 1.98e-07
L12 N11 N12 1.16e-11
R12 N11 N12 6.47e-02
C13 N12 N13 5.85e-08
L13 N12 N13 2.17e-11
R13 N12 N13 8.86e-02
C14 N13 N14 5.30e-08
L14 N13 N14 1.32e-11
R14 N13 N14 7.81e-02
C15 N14 Port2 3.25e-12
L15 N14 Port2 1.10e-09
R15 N14 Port2 1.68e+03
.ENDS KCM55T7U2J783KDL1

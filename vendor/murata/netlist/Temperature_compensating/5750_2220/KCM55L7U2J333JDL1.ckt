*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/3.30e-02[uF]/630[V]
* Murata P/N :KCM55L7U2J333JDL1
* Property : C = 3.30e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55L7U2J333JDL1 Port1 Port2
C01 Port1 N01 3.15e-08
R01 Port1 N01 3.03e+09
L02 N01 N02 4.13e-12
R03 N02 N03 3.06e-03
C04 N03 N04 1.73e-05
R04 N03 N04 1.46e-01
L05 N04 N05 6.40e-11
R05 N04 N05 1.90e-01
L06 N05 N06 3.50e-11
R06 N05 N06 9.49e-03
L07 N06 N07 9.60e-11
R07 N06 N07 3.95e-03
C08 N07 N08 7.59e-08
L08 N07 N08 8.14e-11
R08 N07 N08 3.59e-01
C09 N08 N09 2.63e-08
L09 N08 N09 7.98e-11
R09 N08 N09 3.96e-01
C10 N09 N10 6.98e-08
L10 N09 N10 1.36e-11
R10 N09 N10 7.10e-02
C11 N10 N11 3.60e-08
L11 N10 N11 1.52e-11
R11 N10 N11 1.19e-01
C12 N11 N12 2.02e-08
L12 N11 N12 1.14e-11
R12 N11 N12 5.90e-02
C13 N12 N13 3.76e-12
L13 N12 N13 1.01e-09
R13 N12 N13 8.76e+02
C14 N13 Port2 1.45e-11
L14 N13 Port2 2.36e-10
R14 N13 Port2 4.70e+01
.ENDS KCM55L7U2J333JDL1

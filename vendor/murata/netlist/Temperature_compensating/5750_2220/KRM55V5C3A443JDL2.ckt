*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/4.40e-02[uF]/1000[V]
* Murata P/N :KRM55V5C3A443JDL2
* Property : C = 4.40e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55V5C3A443JDL2 Port1 Port2
C01 Port1 N01 4.26e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.37e-10
R03 N02 N03 3.36e-03
C04 N03 N04 1.53e-05
R04 N03 N04 3.31e-01
L05 N04 N05 6.53e-11
R05 N04 N05 1.23e+00
L06 N05 N06 1.53e-10
R06 N05 N06 1.66e-01
L07 N06 N07 1.80e-10
R07 N06 N07 5.89e-03
C08 N07 N08 9.33e-08
L08 N07 N08 2.51e-10
R08 N07 N08 7.26e-01
C09 N08 N09 9.55e-08
L09 N08 N09 6.17e-11
R09 N08 N09 2.82e-01
C10 N09 N10 1.26e-07
L10 N09 N10 3.55e-11
R10 N09 N10 1.87e-01
C11 N10 N11 4.17e-08
L11 N10 N11 4.68e-11
R11 N10 N11 2.09e-01
C12 N11 N12 7.41e-08
L12 N11 N12 1.26e-11
R12 N11 N12 7.78e-02
C13 N12 N13 7.41e-08
L13 N12 N13 7.59e-12
R13 N12 N13 6.47e-02
C14 N13 Port2 3.09e-12
L14 N13 Port2 1.15e-09
R14 N13 Port2 1.20e+03
.ENDS KRM55V5C3A443JDL2

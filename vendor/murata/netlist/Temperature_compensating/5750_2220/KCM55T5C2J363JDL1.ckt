*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/3.60e-02[uF]/630[V]
* Murata P/N :KCM55T5C2J363JDL1
* Property : C = 3.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55T5C2J363JDL1 Port1 Port2
C01 Port1 N01 3.59e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 3.15e-12
R03 N02 N03 3.34e-03
C04 N03 N04 1.68e-05
R04 N03 N04 1.77e-01
L05 N04 N05 1.33e-10
R05 N04 N05 2.29e-01
L06 N05 N06 4.83e-11
R06 N05 N06 8.68e-03
L07 N06 N07 1.27e-10
R07 N06 N07 3.88e-03
C08 N07 N08 8.55e-08
L08 N07 N08 1.81e-10
R08 N07 N08 7.27e-01
C09 N08 N09 6.49e-08
L09 N08 N09 6.58e-11
R09 N08 N09 3.56e-01
C10 N09 N10 9.16e-08
L10 N09 N10 3.22e-11
R10 N09 N10 1.79e-01
C11 N10 N11 3.03e-08
L11 N10 N11 4.45e-11
R11 N10 N11 2.10e-01
C12 N11 N12 5.65e-08
L12 N11 N12 1.14e-11
R12 N11 N12 8.35e-02
C13 N12 N13 5.65e-08
L13 N12 N13 6.58e-12
R13 N12 N13 5.65e-02
C14 N13 Port2 2.64e-12
L14 N13 Port2 1.12e-09
R14 N13 Port2 8.16e+02
.ENDS KCM55T5C2J363JDL1

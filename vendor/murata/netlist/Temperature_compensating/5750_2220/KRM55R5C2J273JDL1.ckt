*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/2.70e-02[uF]/630[V]
* Murata P/N :KRM55R5C2J273JDL1
* Property : C = 2.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55R5C2J273JDL1 Port1 Port2
C01 Port1 N01 2.67e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.94e-12
R03 N02 N03 4.40e-03
C04 N03 N04 1.05e-05
R04 N03 N04 2.65e-01
L05 N04 N05 5.88e-11
R05 N04 N05 1.06e+00
L06 N05 N06 1.66e-10
R06 N05 N06 2.72e-01
L07 N06 N07 2.34e-11
R07 N06 N07 7.65e-03
L08 N07 N08 1.17e-10
R08 N07 N08 5.94e-03
C09 N08 N09 8.37e-08
L09 N08 N09 8.87e-11
R09 N08 N09 4.40e-01
C10 N09 N10 3.11e-08
L10 N09 N10 9.07e-11
R10 N09 N10 4.71e-01
C11 N10 N11 1.21e-07
L11 N10 N11 1.12e-11
R11 N10 N11 7.82e-02
C12 N11 N12 3.11e-08
L12 N11 N12 2.62e-11
R12 N11 N12 1.46e-01
C13 N12 Port2 2.90e-12
L13 N12 Port2 1.17e-09
R13 N12 Port2 1.49e+03
.ENDS KRM55R5C2J273JDL1

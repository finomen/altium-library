*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/6.80e-03[uF]/250[Vac]
* Murata P/N :KCA55T7UMF682ML01
* Property : C = 6.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55T7UMF682ML01 Port1 Port2
C01 Port1 N01 6.76e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.77e-11
R03 N02 N03 6.99e-03
C04 N03 N04 5.07e-07
R04 N03 N04 9.64e+00
L05 N04 N05 1.25e-10
R05 N04 N05 1.96e+00
L06 N05 N06 1.49e-10
R06 N05 N06 3.99e-02
L07 N06 N07 8.39e-10
R07 N06 N07 1.37e-02
C08 N07 N08 1.39e-08
L08 N07 N08 2.17e-10
R08 N07 N08 2.32e+00
C09 N08 N09 7.20e-09
L09 N08 N09 1.19e-10
R09 N08 N09 1.14e+00
C10 N09 N10 1.83e-08
L10 N09 N10 2.81e-11
R10 N09 N10 4.58e-01
C11 N10 N11 8.58e-09
L11 N10 N11 3.18e-11
R11 N10 N11 5.81e-01
C12 N11 N12 1.28e-08
L12 N11 N12 1.68e-11
R12 N11 N12 2.98e-01
C13 N12 N13 5.46e-09
L13 N12 N13 2.16e-11
R13 N12 N13 3.52e-01
C14 N13 N14 5.44e-09
L14 N13 N14 1.24e-11
R14 N13 N14 2.39e-01
C15 N14 N15 1.59e-08
L15 N14 N15 2.84e-12
R15 N14 N15 1.47e-01
C16 N15 N16 9.37e-10
L16 N15 N16 2.44e-11
R16 N15 N16 2.02e-01
C17 N16 Port2 2.57e-12
L17 N16 Port2 1.20e-09
R17 N16 Port2 8.04e+02
.ENDS KCA55T7UMF682ML01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/6.80e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF681KH01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF681KH01 Port1 Port2
C01 Port1 N01 6.84e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.31e-12
R03 N02 N03 2.58e-02
C04 N03 N04 7.36e-09
R04 N03 N04 6.01e+02
C05 N04 N05 4.14e-07
R05 N04 N05 1.72e+01
L06 N05 N06 1.56e-10
R06 N05 N06 5.45e-02
L07 N06 N07 1.02e-12
R07 N06 N07 1.21e-03
C08 N07 N08 1.80e-09
L08 N07 N08 3.29e-11
R08 N07 N08 1.10e+00
C09 N08 N09 2.93e-10
L09 N08 N09 5.71e-11
R09 N08 N09 2.71e+00
C10 N09 Port2 2.54e-12
L10 N09 Port2 1.64e-09
R10 N09 Port2 3.67e+02
.ENDS KCA55L7UMF681KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/9.40e-02[uF]/630[V]
* Murata P/N :KRM55T7U2J943KDL1
* Property : C = 9.40e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55T7U2J943KDL1 Port1 Port2
C01 Port1 N01 9.40e-08
R01 Port1 N01 1.06e+09
L02 N01 N02 2.99e-11
R03 N02 N03 2.14e-03
C04 N03 N04 1.08e-05
R04 N03 N04 2.20e+00
L05 N04 N05 1.20e-10
R05 N04 N05 1.92e-01
L06 N05 N06 1.17e-10
R06 N05 N06 5.16e-03
C07 N06 N07 1.55e-07
L07 N06 N07 2.51e-10
R07 N06 N07 6.78e-01
C08 N07 N08 1.00e-07
L08 N07 N08 1.29e-10
R08 N07 N08 4.08e-01
C09 N08 N09 1.86e-07
L09 N08 N09 3.98e-11
R09 N08 N09 1.59e-01
C10 N09 N10 8.33e-08
L10 N09 N10 4.89e-11
R10 N09 N10 1.66e-01
C11 N10 N11 2.76e-07
L11 N10 N11 1.07e-11
R11 N10 N11 8.34e-02
C12 N11 N12 4.79e-08
L12 N11 N12 3.71e-11
R12 N11 N12 1.00e-01
C13 N12 N13 7.42e-08
L13 N12 N13 1.38e-11
R13 N12 N13 7.43e-02
C14 N13 N14 4.79e-08
L14 N13 N14 1.29e-11
R14 N13 N14 5.64e-02
C15 N14 Port2 3.10e-12
L15 N14 Port2 9.99e-10
R15 N14 Port2 1.21e+03
.ENDS KRM55T7U2J943KDL1

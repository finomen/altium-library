*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/4.70e-02[uF]/630[V]
* Murata P/N :KRM55L7U2J473JDL1
* Property : C = 4.70e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55L7U2J473JDL1 Port1 Port2
C01 Port1 N01 4.42e-08
R01 Port1 N01 2.13e+09
L02 N01 N02 1.07e-11
R03 N02 N03 2.48e-03
C04 N03 N04 2.30e-05
R04 N03 N04 9.19e-02
C05 N04 N05 1.87e-03
R05 N04 N05 1.62e-03
L06 N05 N06 1.12e-10
R06 N05 N06 1.40e-01
L07 N06 N07 1.85e-11
R07 N06 N07 6.06e-03
L08 N07 N08 1.01e-10
R08 N07 N08 3.80e-03
C09 N08 N09 1.10e-07
L09 N08 N09 1.01e-10
R09 N08 N09 4.25e-01
C10 N09 N10 4.65e-08
L10 N09 N10 8.80e-11
R10 N09 N10 3.93e-01
C11 N10 N11 9.14e-08
L11 N10 N11 2.03e-11
R11 N10 N11 8.07e-02
C12 N11 N12 5.56e-08
L12 N11 N12 1.92e-11
R12 N11 N12 1.07e-01
C13 N12 N13 3.57e-08
L13 N12 N13 1.53e-11
R13 N12 N13 4.79e-02
C14 N13 Port2 2.88e-12
L14 N13 Port2 1.19e-09
R14 N13 Port2 1.07e+03
.ENDS KRM55L7U2J473JDL1

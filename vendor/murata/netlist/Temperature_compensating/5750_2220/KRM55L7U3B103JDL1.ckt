*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.00e-02[uF]/1250[V]
* Murata P/N :KRM55L7U3B103JDL1
* Property : C = 1.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55L7U3B103JDL1 Port1 Port2
C01 Port1 N01 1.00e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-11
R03 N02 N03 2.76e-03
C04 N03 N04 1.51e-06
R04 N03 N04 1.93e+00
C05 N04 N05 1.04e-04
R05 N04 N05 3.25e-03
L06 N05 N06 9.64e-11
R06 N05 N06 5.76e-01
L07 N06 N07 3.24e-11
R07 N06 N07 2.20e-02
L08 N07 N08 6.89e-11
R08 N07 N08 7.95e-03
C09 N08 N09 2.07e-08
L09 N08 N09 1.13e-10
R09 N08 N09 8.59e-01
C10 N09 N10 8.85e-09
L10 N09 N10 9.26e-11
R10 N09 N10 9.57e-01
C11 N10 N11 3.39e-08
L11 N10 N11 1.08e-11
R11 N10 N11 2.26e-01
C12 N11 N12 1.12e-08
L12 N11 N12 1.98e-11
R12 N11 N12 3.63e-01
C13 N12 N13 6.02e-09
L13 N12 N13 1.59e-11
R13 N12 N13 1.42e-01
C14 N13 Port2 2.77e-12
L14 N13 Port2 1.11e-09
R14 N13 Port2 1.13e+03
.ENDS KRM55L7U3B103JDL1

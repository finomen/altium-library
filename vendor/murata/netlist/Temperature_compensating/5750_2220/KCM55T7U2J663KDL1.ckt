*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/6.60e-02[uF]/630[V]
* Murata P/N :KCM55T7U2J663KDL1
* Property : C = 6.60e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55T7U2J663KDL1 Port1 Port2
C01 Port1 N01 6.53e-08
R01 Port1 N01 1.52e+09
L02 N01 N02 1.72e-11
R03 N02 N03 2.04e-03
C04 N03 N04 2.34e-05
R04 N03 N04 1.88e-01
L05 N04 N05 9.78e-11
R05 N04 N05 1.97e-01
L06 N05 N06 5.02e-11
R06 N05 N06 9.02e-03
L07 N06 N07 1.23e-10
R07 N06 N07 3.20e-03
C08 N07 N08 1.32e-07
L08 N07 N08 2.14e-10
R08 N07 N08 6.69e-01
C09 N08 N09 9.34e-08
L09 N08 N09 7.59e-11
R09 N08 N09 2.92e-01
C10 N09 N10 1.48e-07
L10 N09 N10 3.31e-11
R10 N09 N10 1.72e-01
C11 N10 N11 3.89e-08
L11 N10 N11 5.25e-11
R11 N10 N11 1.76e-01
C12 N11 N12 6.61e-08
L12 N11 N12 1.41e-11
R12 N11 N12 7.86e-02
C13 N12 N13 5.01e-08
L13 N12 N13 1.12e-11
R13 N12 N13 7.68e-02
C14 N13 Port2 3.16e-12
L14 N13 Port2 1.12e-09
R14 N13 Port2 1.57e+03
.ENDS KCM55T7U2J663KDL1

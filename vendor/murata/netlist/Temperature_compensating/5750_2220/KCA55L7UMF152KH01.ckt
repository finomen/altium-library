*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/1.50e-03[uF]/250[Vac]
* Murata P/N :KCA55L7UMF152KH01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF152KH01 Port1 Port2
C01 Port1 N01 1.62e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.05e-11
R03 N02 N03 4.70e-03
C04 N03 N04 2.27e-08
R04 N03 N04 2.20e+02
C05 N04 N05 2.62e-06
R05 N04 N05 6.60e-03
L06 N05 N06 5.76e-11
R06 N05 N06 3.67e-02
L07 N06 N07 3.46e-10
R07 N06 N07 2.80e-02
C08 N07 N08 3.39e-09
L08 N07 N08 7.55e-11
R08 N07 N08 1.50e+00
C09 N08 N09 1.36e-09
L09 N08 N09 6.10e-11
R09 N08 N09 1.82e+00
C10 N09 N10 2.97e-09
L10 N09 N10 1.28e-11
R10 N09 N10 3.50e-01
C11 N10 N11 8.36e-10
L11 N10 N11 2.43e-11
R11 N10 N11 7.55e-01
C12 N11 N12 3.16e-10
L12 N11 N12 2.68e-11
R12 N11 N12 7.91e-01
C13 N12 Port2 2.66e-12
L13 N12 Port2 1.22e-09
R13 N12 Port2 6.01e+02
.ENDS KCA55L7UMF152KH01

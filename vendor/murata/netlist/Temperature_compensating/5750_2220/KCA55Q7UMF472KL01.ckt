*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/4.70e-03[uF]/250[Vac]
* Murata P/N :KCA55Q7UMF472KL01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55Q7UMF472KL01 Port1 Port2
C01 Port1 N01 4.67e-09
R01 Port1 N01 1.00e+10
L02 N01 N02 1.74e-12
R03 N02 N03 1.23e-02
C04 N03 N04 1.89e-07
R04 N03 N04 2.96e+01
C05 N04 N05 5.91e-05
R05 N04 N05 7.76e-03
L06 N05 N06 1.24e-10
R06 N05 N06 2.06e+00
L07 N06 N07 2.27e-10
R07 N06 N07 2.48e-02
C08 N07 N08 8.52e-09
L08 N07 N08 1.58e-10
R08 N07 N08 1.32e+00
C09 N08 N09 4.29e-09
L09 N08 N09 1.16e-10
R09 N08 N09 1.23e+00
C10 N09 N10 1.23e-08
L10 N09 N10 1.84e-11
R10 N09 N10 3.63e-01
C11 N10 N11 4.86e-09
L11 N10 N11 2.87e-11
R11 N10 N11 5.87e-01
C12 N11 N12 1.36e-08
L12 N11 N12 6.25e-12
R12 N11 N12 1.26e-01
C13 N12 N13 1.41e-08
L13 N12 N13 4.46e-12
R13 N12 N13 1.84e-01
C14 N13 N14 5.40e-10
L14 N13 N14 5.70e-11
R14 N13 N14 2.88e-01
C15 N14 Port2 2.77e-12
L15 N14 Port2 1.20e-09
R15 N14 Port2 8.50e+02
.ENDS KCA55Q7UMF472KL01

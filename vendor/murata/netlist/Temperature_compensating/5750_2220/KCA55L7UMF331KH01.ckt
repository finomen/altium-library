*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/3.30e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF331KH01
* Property : C = 3.30e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF331KH01 Port1 Port2
C01 Port1 N01 3.14e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 2.10e-11
R03 N02 N03 3.55e-03
C04 N03 N04 1.63e-06
R04 N03 N04 2.61e-02
L05 N04 N05 1.13e-10
R05 N04 N05 6.82e-02
C06 N05 N06 7.90e-10
L06 N05 N06 5.50e-11
R06 N05 N06 3.14e+00
C07 N06 N07 1.59e-10
L07 N06 N07 8.17e-11
R07 N06 N07 6.69e+00
C08 N07 N08 2.73e-10
L08 N07 N08 2.12e-11
R08 N07 N08 4.38e+00
C09 N08 N09 4.21e-12
L09 N08 N09 9.19e-10
R09 N08 N09 4.00e+02
C10 N09 N10 1.03e-11
L10 N09 N10 3.67e-10
R10 N09 N10 1.39e+02
C11 N10 Port2 2.28e-11
L11 N10 Port2 1.44e-10
R11 N10 Port2 4.51e+01
.ENDS KCA55L7UMF331KH01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/3.00e-02[uF]/630[V]
* Murata P/N :KRM55T5C2J303JDL1
* Property : C = 3.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55T5C2J303JDL1 Port1 Port2
C01 Port1 N01 2.99e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 5.45e-11
R03 N02 N03 3.80e-03
C04 N03 N04 1.40e-05
R04 N03 N04 1.91e-01
L05 N04 N05 1.01e-10
R05 N04 N05 2.95e-01
L06 N05 N06 4.74e-11
R06 N05 N06 1.07e-02
L07 N06 N07 1.27e-10
R07 N06 N07 4.08e-03
C08 N07 N08 7.91e-08
L08 N07 N08 1.71e-10
R08 N07 N08 6.39e-01
C09 N08 N09 5.35e-08
L09 N08 N09 5.79e-11
R09 N08 N09 2.79e-01
C10 N09 N10 8.28e-08
L10 N09 N10 2.83e-11
R10 N09 N10 1.50e-01
C11 N10 N11 2.08e-08
L11 N10 N11 4.70e-11
R11 N10 N11 2.43e-01
C12 N11 N12 4.76e-08
L12 N11 N12 9.38e-12
R12 N11 N12 7.34e-02
C13 N12 N13 3.78e-08
L13 N12 N13 6.80e-12
R13 N12 N13 5.97e-02
C14 N13 Port2 2.62e-12
L14 N13 Port2 1.13e-09
R14 N13 Port2 9.68e+02
.ENDS KRM55T5C2J303JDL1

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/2.00e-02[uF]/1000[V]
* Murata P/N :KCM55T7U3A203KDL1
* Property : C = 2.00e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55T7U3A203KDL1 Port1 Port2
C01 Port1 N01 2.00e-08
R01 Port1 N01 5.00e+09
L02 N01 N02 4.51e-11
R03 N02 N03 2.30e-03
C04 N03 N04 3.37e-06
R04 N03 N04 1.28e+00
L05 N04 N05 1.30e-10
R05 N04 N05 4.14e-01
L06 N05 N06 8.97e-11
R06 N05 N06 6.42e-03
L07 N06 N07 8.37e-12
R07 N06 N07 4.44e-03
C08 N07 N08 3.28e-08
L08 N07 N08 2.60e-10
R08 N07 N08 1.53e+00
C09 N08 N09 2.38e-08
L09 N08 N09 1.08e-10
R09 N08 N09 6.70e-01
C10 N09 N10 3.36e-08
L10 N09 N10 4.41e-11
R10 N09 N10 3.51e-01
C11 N10 N11 2.55e-08
L11 N10 N11 3.20e-11
R11 N10 N11 3.68e-01
C12 N11 N12 4.04e-08
L12 N11 N12 1.53e-11
R12 N11 N12 2.12e-01
C13 N12 N13 5.83e-08
L13 N12 N13 6.37e-12
R13 N12 N13 1.19e-01
C14 N13 N14 4.53e-08
L14 N13 N14 7.15e-12
R14 N13 N14 1.04e-01
C15 N14 N15 2.43e-08
L15 N14 N15 8.40e-12
R15 N14 N15 1.50e-01
C16 N15 N16 4.53e-08
L16 N15 N16 2.85e-12
R16 N15 N16 7.87e-02
C17 N16 Port2 3.13e-12
L17 N16 Port2 1.03e-09
R17 N16 Port2 7.51e+02
.ENDS KCM55T7U3A203KDL1

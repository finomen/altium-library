*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/U2J(-55to125[deg])/4.70e-04[uF]/250[Vac]
* Murata P/N :KCA55L7UMF471KH01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCA55L7UMF471KH01 Port1 Port2
C01 Port1 N01 4.92e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.31e-09
R03 N02 N03 7.50e-03
C04 N03 N04 2.14e-08
R04 N03 N04 4.36e+05
C05 N04 N05 8.52e-09
R05 N04 N05 3.88e+03
C06 N05 N06 5.55e-08
R06 N05 N06 4.23e+01
L07 N06 N07 5.04e-11
R07 N06 N07 8.77e-02
L08 N07 N08 5.82e-11
R08 N07 N08 1.50e-02
C09 N08 N09 6.59e-06
L09 N08 N09 2.52e-10
R09 N08 N09 2.43e-01
C10 N09 N10 1.22e-09
L10 N09 N10 6.89e-11
R10 N09 N10 3.52e+00
C11 N10 N11 4.06e-10
L11 N10 N11 6.35e-11
R11 N10 N11 3.40e+00
C12 N11 N12 1.25e-09
L12 N11 N12 9.68e-12
R12 N11 N12 1.08e+00
C13 N12 Port2 2.63e-10
L13 N12 Port2 2.67e-11
R13 N12 Port2 1.99e+00
.ENDS KCA55L7UMF471KH01

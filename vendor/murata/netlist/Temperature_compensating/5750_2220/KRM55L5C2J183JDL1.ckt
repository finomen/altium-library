*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G(-55to125[deg])/1.80e-02[uF]/630[V]
* Murata P/N :KRM55L5C2J183JDL1
* Property : C = 1.80e-02[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55L5C2J183JDL1 Port1 Port2
C01 Port1 N01 1.79e-08
R01 Port1 N01 1.00e+10
L02 N01 N02 1.10e-11
R03 N02 N03 5.19e-03
C04 N03 N04 4.96e-06
R04 N03 N04 6.40e-01
L05 N04 N05 1.21e-10
R05 N04 N05 2.83e-01
L06 N05 N06 3.78e-11
R06 N05 N06 1.10e-02
L07 N06 N07 1.32e-10
R07 N06 N07 5.56e-03
C08 N07 N08 5.53e-08
L08 N07 N08 7.13e-11
R08 N07 N08 3.80e-01
C09 N08 N09 1.77e-08
L09 N08 N09 7.76e-11
R09 N08 N09 4.57e-01
C10 N09 N10 8.14e-08
L10 N09 N10 7.89e-12
R10 N09 N10 6.61e-02
C11 N10 N11 2.54e-08
L11 N10 N11 1.48e-11
R11 N10 N11 1.10e-01
C12 N11 Port2 2.61e-12
L12 N11 Port2 1.24e-09
R12 N11 Port2 1.23e+03
.ENDS KRM55L5C2J183JDL1

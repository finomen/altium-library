*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H270JB01
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H270JB01 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 9.72e-12
R03 N02 N03 2.91e-02
C04 N03 N04 3.71e-11
L04 N03 N04 7.39e-11
R04 N03 N04 1.33e+02
C05 N04 N05 9.45e-12
L05 N04 N05 1.07e-10
R05 N04 N05 2.47e+02
C06 N05 N06 3.73e-12
L06 N05 N06 1.42e-10
R06 N05 N06 4.20e+02
C07 N06 Port2 2.71e-12
L07 N06 Port2 1.39e-10
R07 N06 Port2 9.23e+02
.ENDS GQM22M5C2H270JB01

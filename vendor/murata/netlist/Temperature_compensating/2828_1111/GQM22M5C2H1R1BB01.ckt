*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R1BB01
* Property : C = 1.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R1BB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.62e-10
R03 N02 N03 1.70e-01
C04 N03 N04 2.95e-12
L04 N03 N04 1.02e-10
C05 N04 Port2 1.87e-10
L05 N04 Port2 1.89e-12
R05 N04 Port2 8.53e-01
.ENDS GQM22M5C2H1R1BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R7BB01
* Property : C = 2.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R7BB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.68e-10
R03 N02 N03 6.00e-02
C04 N03 N04 7.07e-10
L04 N03 N04 4.85e-13
C05 N04 Port2 2.93e-12
L05 N04 Port2 1.93e-10
R05 N04 Port2 2.72e+03
.ENDS GQM22M5C2H2R7BB01

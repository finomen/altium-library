*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/7.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H750JB01
* Property : C = 7.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H750JB01 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.88e-11
R03 N02 N03 2.74e-02
C04 N03 N04 9.72e-11
L04 N03 N04 7.64e-11
R04 N03 N04 5.45e+01
C05 N04 N05 4.68e-11
L05 N04 N05 5.56e-11
R05 N04 N05 5.76e+01
C06 N05 N06 4.60e-11
L06 N05 N06 2.73e-11
R06 N05 N06 4.04e+01
C07 N06 N07 1.21e-11
L07 N06 N07 6.71e-11
R07 N06 N07 1.17e+02
C08 N07 N08 4.85e-12
L08 N07 N08 1.25e-10
R08 N07 N08 2.88e+02
C09 N08 N09 1.25e-11
L09 N08 N09 4.10e-11
R09 N08 N09 9.04e+01
C10 N09 Port2 4.94e-11
L10 N09 Port2 8.20e-12
R10 N09 Port2 1.66e+01
.ENDS GQM22M5C2H750JB01

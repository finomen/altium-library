*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R1DB01
* Property : C = 5.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R1DB01 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.26e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.14e-12
R04 N03 N04 1.46e-01
C05 N04 N05 3.91e-11
L05 N04 N05 8.52e-12
C06 N05 N06 7.37e-12
L06 N05 N06 4.78e-11
R06 N05 N06 2.16e+02
C07 N06 Port2 3.22e-12
L07 N06 Port2 2.21e-10
R07 N06 Port2 4.94e+03
.ENDS GQM22M5C2H5R1DB01

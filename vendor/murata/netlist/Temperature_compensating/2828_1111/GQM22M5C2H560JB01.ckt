*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H560JB01
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H560JB01 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.58e-11
R03 N02 N03 2.75e-02
C04 N03 N04 8.31e-11
L04 N03 N04 6.57e-11
R04 N03 N04 6.70e+01
C05 N04 N05 3.32e-11
L05 N04 N05 5.94e-11
R05 N04 N05 9.84e+01
C06 N05 N06 2.22e-11
L06 N05 N06 4.31e-11
R06 N05 N06 5.82e+01
C07 N06 N07 6.53e-12
L07 N06 N07 1.01e-10
R07 N06 N07 2.40e+02
C08 N07 N08 5.02e-12
L08 N07 N08 1.02e-10
R08 N07 N08 2.38e+02
C09 N08 N09 1.49e-11
L09 N08 N09 2.82e-11
R09 N08 N09 5.90e+01
C10 N09 Port2 2.17e-11
L10 N09 Port2 1.60e-11
R10 N09 Port2 4.19e+01
.ENDS GQM22M5C2H560JB01

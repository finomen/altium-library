*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/9.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H910JB01
* Property : C = 9.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H910JB01 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.91e-11
R03 N02 N03 2.62e-02
C04 N03 N04 1.23e-10
L04 N03 N04 7.29e-11
R04 N03 N04 5.58e+01
C05 N04 N05 6.01e-11
L05 N04 N05 5.20e-11
R05 N04 N05 5.71e+01
C06 N05 N06 5.99e-11
L06 N05 N06 2.49e-11
R06 N05 N06 3.80e+01
C07 N06 N07 1.58e-11
L07 N06 N07 6.04e-11
R07 N06 N07 1.03e+02
C08 N07 N08 5.12e-12
L08 N07 N08 1.36e-10
R08 N07 N08 3.02e+02
C09 N08 N09 1.00e-11
L09 N08 N09 5.90e-11
R09 N08 N09 1.25e+02
C10 N09 N10 4.38e-11
L10 N09 N10 1.07e-11
R10 N09 N10 2.23e+01
C11 N10 N11 2.56e-10
L11 N10 N11 1.52e-12
R11 N10 N11 3.55e+00
C12 N11 Port2 2.50e-10
L12 N11 Port2 1.32e-12
R12 N11 Port2 4.72e-01
.ENDS GQM22M5C2H910JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R7BB01
* Property : C = 4.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.15e-10
R03 N02 N03 4.00e-02
L04 N03 N04 3.79e-12
R04 N03 N04 8.94e-02
C05 N04 N05 7.84e-12
L05 N04 N05 4.22e-11
C06 N05 N06 4.78e-11
L06 N05 N06 7.33e-12
R06 N05 N06 1.10e+01
C07 N06 Port2 3.06e-12
L07 N06 Port2 2.33e-10
R07 N06 Port2 3.72e+03
.ENDS GQM22M5C2H4R7BB01

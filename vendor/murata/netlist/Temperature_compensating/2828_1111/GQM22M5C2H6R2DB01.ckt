*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R2DB01
* Property : C = 6.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R2DB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 6.90e-11
R03 N02 N03 3.50e-02
C04 N03 N04 4.60e-12
L04 N03 N04 8.88e-11
R04 N03 N04 3.14e+02
C05 N04 Port2 3.40e-12
L05 N04 Port2 2.43e-10
R05 N04 Port2 7.52e+02
.ENDS GQM22M5C2H6R2DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H1R0CB01
* Property : C = 1.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H1R0CB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.59e-10
R03 N02 N03 2.30e-01
C04 N03 N04 6.00e-12
L04 N03 N04 5.59e-11
C05 N04 Port2 8.17e-11
L05 N04 Port2 3.78e-12
R05 N04 Port2 1.08e+00
.ENDS GQM22M5C2H1R0CB01

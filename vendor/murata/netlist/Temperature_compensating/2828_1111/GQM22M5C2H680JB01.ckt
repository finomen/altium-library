*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H680JB01
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H680JB01 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-11
R03 N02 N03 2.48e-02
C04 N03 N04 9.11e-11
L04 N03 N04 7.29e-11
R04 N03 N04 6.73e+01
C05 N04 N05 3.84e-11
L05 N04 N05 6.02e-11
R05 N04 N05 6.94e+01
C06 N05 N06 3.24e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.60e+01
C07 N06 N07 8.60e-12
L07 N06 N07 8.54e-11
R07 N06 N07 1.76e+02
C08 N07 N08 4.50e-12
L08 N07 N08 1.22e-10
R08 N07 N08 3.06e+02
C09 N08 N09 8.72e-12
L09 N08 N09 5.29e-11
R09 N08 N09 1.42e+02
C10 N09 N10 1.67e-11
L10 N09 N10 2.30e-11
R10 N09 N10 5.04e+01
C11 N10 Port2 1.32e-11
L11 N10 Port2 2.73e-11
R11 N10 Port2 2.54e+02
.ENDS GQM22M5C2H680JB01

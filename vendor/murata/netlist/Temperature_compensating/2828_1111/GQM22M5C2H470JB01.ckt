*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.70e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H470JB01
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H470JB01 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 6.74e-11
L04 N03 N04 6.77e-11
R04 N03 N04 1.31e+02
C05 N04 N05 2.14e-11
L05 N04 N05 7.53e-11
R05 N04 N05 1.71e+02
C06 N05 N06 1.24e-11
L06 N05 N06 6.08e-11
R06 N05 N06 1.38e+02
C07 N06 N07 3.04e-12
L07 N06 N07 1.61e-10
R07 N06 N07 3.82e+02
C08 N07 Port2 2.06e-12
L08 N07 Port2 1.54e-10
R08 N07 Port2 1.24e+02
.ENDS GQM22M5C2H470JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H620GB01
* Property : C = 6.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H620GB01 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.54e-11
R03 N02 N03 2.69e-02
C04 N03 N04 7.63e-11
L04 N03 N04 7.91e-11
R04 N03 N04 8.39e+01
C05 N04 N05 3.04e-11
L05 N04 N05 6.87e-11
R05 N04 N05 1.04e+02
C06 N05 N06 1.53e-11
L06 N05 N06 6.47e-11
R06 N05 N06 1.23e+02
C07 N06 N07 4.28e-12
L07 N06 N07 1.65e-10
R07 N06 N07 3.78e+02
C08 N07 N08 1.28e-11
L08 N07 N08 4.07e-11
R08 N07 N08 9.50e+01
C09 N08 Port2 9.18e-11
L09 N08 Port2 4.08e-12
R09 N08 Port2 8.71e+00
.ENDS GQM22M5C2H620GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H360JB01
* Property : C = 3.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H360JB01 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 4.13e-11
R03 N02 N03 3.01e-02
C04 N03 N04 3.86e-11
L04 N03 N04 9.54e-11
R04 N03 N04 1.09e+02
C05 N04 N05 1.28e-11
L05 N04 N05 1.07e-10
R05 N04 N05 1.93e+02
C06 N05 N06 5.19e-12
L06 N05 N06 1.42e-10
R06 N05 N06 3.63e+02
C07 N06 N07 9.41e-12
L07 N06 N07 5.92e-11
R07 N06 N07 1.72e+02
C08 N07 Port2 4.33e-11
L08 N07 Port2 8.92e-12
R08 N07 Port2 2.84e+01
.ENDS GQM22M5C2H360JB01

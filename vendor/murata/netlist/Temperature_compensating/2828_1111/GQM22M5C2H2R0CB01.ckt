*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.00e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H2R0CB01
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H2R0CB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 7.00e-02
C04 N03 Port2 2.98e-12
L04 N03 Port2 1.69e-10
R04 N03 Port2 2.14e+03
.ENDS GQM22M5C2H2R0CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.00e-04[uF]/500[V]
* Murata P/N :GQM22M5C2H101JB01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H101JB01 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.34e-02
C04 N03 N04 1.39e-10
L04 N03 N04 7.10e-11
R04 N03 N04 6.49e+01
C05 N04 N05 7.42e-11
L05 N04 N05 4.51e-11
R05 N04 N05 5.62e+01
C06 N05 N06 9.93e-11
L06 N05 N06 1.57e-11
R06 N05 N06 2.40e+01
C07 N06 N07 4.21e-11
L07 N06 N07 2.22e-11
R07 N06 N07 3.66e+01
C08 N07 N08 2.87e-11
L08 N07 N08 2.14e-11
R08 N07 N08 3.94e+01
C09 N08 N09 6.73e-12
L09 N08 N09 6.89e-11
R09 N08 N09 1.11e+02
C10 N09 Port2 4.91e-12
L10 N09 Port2 7.65e-11
R10 N09 Port2 9.44e+01
.ENDS GQM22M5C2H101JB01

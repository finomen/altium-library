*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H110GB01
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.19e-10
R03 N02 N03 2.95e-02
L04 N03 N04 1.71e-13
R04 N03 N04 4.21e-03
C05 N04 N05 7.40e-12
L05 N04 N05 1.70e-10
R05 N04 N05 4.09e+02
C06 N05 N06 5.04e-12
L06 N05 N06 1.29e-10
R06 N05 N06 3.56e+02
C07 N06 N07 1.55e-10
L07 N06 N07 2.13e-12
R07 N06 N07 2.90e+00
C08 N07 Port2 1.97e-10
L08 N07 Port2 8.53e-14
R08 N07 Port2 1.86e+00
.ENDS GQM22M5C2H110GB01

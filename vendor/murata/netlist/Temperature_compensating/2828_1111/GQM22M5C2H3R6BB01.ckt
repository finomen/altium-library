*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H3R6BB01
* Property : C = 3.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 5.50e-02
C04 N03 N04 1.93e-09
L04 N03 N04 1.80e-13
C05 N04 N05 3.73e-10
L05 N04 N05 8.39e-13
R05 N04 N05 5.22e-01
C06 N05 Port2 3.00e-12
L06 N05 Port2 2.09e-10
R06 N05 Port2 1.32e+03
.ENDS GQM22M5C2H3R6BB01

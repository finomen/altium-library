*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.90e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H390GB01
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H390GB01 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.00e-12
R03 N02 N03 2.50e-02
C04 N03 N04 4.16e-11
L04 N03 N04 9.69e-11
R04 N03 N04 1.28e+02
C05 N04 N05 1.76e-11
L05 N04 N05 8.32e-11
R05 N04 N05 1.36e+02
C06 N05 N06 1.34e-11
L06 N05 N06 5.58e-11
R06 N05 N06 1.21e+02
C07 N06 N07 4.97e-12
L07 N06 N07 1.06e-10
R07 N06 N07 2.65e+02
C08 N07 N08 4.35e-12
L08 N07 N08 9.14e-11
R08 N07 N08 2.12e+02
C09 N08 Port2 8.81e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 2.08e+02
.ENDS GQM22M5C2H390GB01

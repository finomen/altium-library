*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/6.80e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H6R8CB01
* Property : C = 6.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H6R8CB01 Port1 Port2
C01 Port1 N01 6.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 3.09e-12
R04 N03 N04 1.30e-01
C05 N04 N05 3.12e-12
L05 N04 N05 1.35e-10
R05 N04 N05 2.83e+03
C06 N05 Port2 3.74e-12
L06 N05 Port2 2.28e-10
R06 N05 Port2 2.36e+03
.ENDS GQM22M5C2H6R8CB01

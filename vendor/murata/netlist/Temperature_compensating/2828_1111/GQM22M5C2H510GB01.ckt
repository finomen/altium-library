*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.10e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H510GB01
* Property : C = 5.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H510GB01 Port1 Port2
C01 Port1 N01 5.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 3.96e-11
R03 N02 N03 2.93e-02
C04 N03 N04 5.82e-11
L04 N03 N04 8.75e-11
R04 N03 N04 1.06e+02
C05 N04 N05 2.27e-11
L05 N04 N05 7.77e-11
R05 N04 N05 1.34e+02
C06 N05 N06 9.18e-12
L06 N05 N06 9.44e-11
R06 N05 N06 2.12e+02
C07 N06 N07 4.83e-12
L07 N06 N07 1.34e-10
R07 N06 N07 3.76e+02
C08 N07 N08 2.15e-11
L08 N07 N08 2.14e-11
R08 N07 N08 5.82e+01
C09 N08 Port2 3.89e-10
L09 N08 Port2 8.74e-13
R09 N08 Port2 1.03e+00
.ENDS GQM22M5C2H510GB01

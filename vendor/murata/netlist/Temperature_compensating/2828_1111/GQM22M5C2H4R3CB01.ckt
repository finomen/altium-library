*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H4R3CB01
* Property : C = 4.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H4R3CB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 4.50e-02
C04 N03 N04 7.07e-11
L04 N03 N04 3.98e-12
C05 N04 N05 9.34e-12
L05 N04 N05 3.40e-11
R05 N04 N05 3.41e+02
C06 N05 Port2 3.06e-12
L06 N05 Port2 2.20e-10
R06 N05 Port2 2.74e+03
.ENDS GQM22M5C2H4R3CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.40e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H240GB01
* Property : C = 2.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H240GB01 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.05e-11
R03 N02 N03 3.02e-02
C04 N03 N04 2.65e-11
L04 N03 N04 9.36e-11
R04 N03 N04 1.71e+02
C05 N04 N05 7.37e-12
L05 N04 N05 1.39e-10
R05 N04 N05 3.59e+02
C06 N05 N06 5.42e-12
L06 N05 N06 1.16e-10
R06 N05 N06 3.39e+02
C07 N06 N07 2.93e-11
L07 N06 N07 1.54e-11
R07 N06 N07 3.48e+01
C08 N07 Port2 4.04e-11
L08 N07 Port2 7.47e-12
R08 N07 Port2 3.41e+01
.ENDS GQM22M5C2H240GB01

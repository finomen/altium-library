*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/3.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H330JB01
* Property : C = 3.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H330JB01 Port1 Port2
C01 Port1 N01 3.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.00e-11
R03 N02 N03 2.99e-02
C04 N03 N04 4.72e-11
L04 N03 N04 6.95e-11
R04 N03 N04 8.43e+01
C05 N04 N05 1.33e-11
L05 N04 N05 8.89e-11
R05 N04 N05 2.00e+02
C06 N05 N06 4.33e-12
L06 N05 N06 1.40e-10
R06 N05 N06 3.34e+02
C07 N06 N07 7.09e-12
L07 N06 N07 6.41e-11
R07 N06 N07 2.49e+02
C08 N07 Port2 1.42e-11
L08 N07 Port2 2.21e-11
R08 N07 Port2 1.87e+01
.ENDS GQM22M5C2H330JB01

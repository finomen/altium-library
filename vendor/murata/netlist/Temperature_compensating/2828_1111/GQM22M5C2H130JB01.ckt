*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H130JB01
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.60e-11
R03 N02 N03 2.93e-02
C04 N03 N04 8.97e-12
L04 N03 N04 1.61e-10
R04 N03 N04 4.08e+02
C05 N04 N05 4.05e-12
L05 N04 N05 1.69e-10
R05 N04 N05 4.20e+02
C06 N05 Port2 1.92e-11
L06 N05 Port2 1.94e-11
R06 N05 Port2 7.40e+01
.ENDS GQM22M5C2H130JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/2.20e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H220GB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-13
R03 N02 N03 3.00e-02
C04 N03 N04 2.80e-11
L04 N03 N04 8.06e-11
R04 N03 N04 1.18e+02
C05 N04 N05 6.48e-12
L05 N04 N05 1.34e-10
R05 N04 N05 4.83e+02
C06 N05 N06 2.91e-12
L06 N05 N06 1.57e-10
R06 N05 N06 5.11e+02
C07 N06 Port2 3.58e-12
L07 N06 Port2 8.80e-11
R07 N06 Port2 3.45e+02
.ENDS GQM22M5C2H220GB01

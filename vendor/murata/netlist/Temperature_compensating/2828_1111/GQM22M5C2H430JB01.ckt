*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/4.30e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H430JB01
* Property : C = 4.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H430JB01 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 5.28e-11
R03 N02 N03 2.69e-02
C04 N03 N04 5.05e-11
L04 N03 N04 8.63e-11
R04 N03 N04 1.27e+02
C05 N04 N05 1.86e-11
L05 N04 N05 8.31e-11
R05 N04 N05 1.75e+02
C06 N05 N06 6.86e-12
L06 N05 N06 1.15e-10
R06 N05 N06 2.97e+02
C07 N06 N07 6.08e-12
L07 N06 N07 9.86e-11
R07 N06 N07 3.14e+02
C08 N07 Port2 2.91e-11
L08 N07 Port2 1.44e-11
R08 N07 Port2 4.69e+01
.ENDS GQM22M5C2H430JB01

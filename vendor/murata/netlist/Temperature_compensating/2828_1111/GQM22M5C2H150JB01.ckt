*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/1.50e-05[uF]/500[V]
* Murata P/N :GQM22M5C2H150JB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H150JB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 7.25e-11
R03 N02 N03 3.02e-02
C04 N03 N04 1.26e-11
L04 N03 N04 1.31e-10
R04 N03 N04 2.59e+02
C05 N04 N05 4.00e-12
L05 N04 N05 1.73e-10
R05 N04 N05 3.90e+02
C06 N05 Port2 6.06e-12
L06 N05 Port2 6.49e-11
R06 N05 Port2 1.81e+02
.ENDS GQM22M5C2H150JB01

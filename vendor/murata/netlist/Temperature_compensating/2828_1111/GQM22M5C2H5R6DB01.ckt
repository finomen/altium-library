*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :2828M(1111)/C0G(-55to125[deg])/5.60e-06[uF]/500[V]
* Murata P/N :GQM22M5C2H5R6DB01
* Property : C = 5.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM22M5C2H5R6DB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 8.50e-11
R03 N02 N03 3.50e-02
L04 N03 N04 1.63e-12
R04 N03 N04 8.37e-02
C05 N04 N05 7.34e-11
L05 N04 N05 4.38e-12
C06 N05 N06 5.17e-12
L06 N05 N06 7.24e-11
R06 N05 N06 2.20e+03
C07 N06 Port2 3.43e-12
L07 N06 Port2 2.28e-10
R07 N06 Port2 2.89e+03
.ENDS GQM22M5C2H5R6DB01

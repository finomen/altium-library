*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R6BB12
* Property : C = 1.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R6BB12 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.03e-10
R03 N02 N03 2.20e-01
L04 N03 N04 2.07e-12
R04 N03 N04 2.74e-01
C05 N04 Port2 7.35e-12
L05 N04 Port2 3.38e-11
.ENDS GQM1875G2E1R6BB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R0BB12
* Property : C = 5.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R0BB12 Port1 Port2
C01 Port1 N01 5.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.16e-10
R03 N02 N03 1.00e-01
L04 N03 N04 3.80e-12
R04 N03 N04 3.58e-01
C05 N04 N05 2.00e-12
L05 N04 N05 1.25e-10
C06 N05 N06 5.57e-12
L06 N05 N06 7.12e-11
R06 N05 N06 1.91e+02
C07 N06 Port2 3.30e-09
L07 N06 Port2 1.77e-13
R07 N06 Port2 6.03e-02
.ENDS GQM1875C2E5R0BB12

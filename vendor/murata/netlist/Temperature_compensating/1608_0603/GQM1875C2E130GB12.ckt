*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E130GB12
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E130GB12 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.20e-10
R03 N02 N03 6.09e-02
L04 N03 N04 5.83e-12
R04 N03 N04 1.86e-02
C05 N04 N05 2.86e-11
L05 N04 N05 3.52e-11
R05 N04 N05 5.42e+01
C06 N05 N06 1.19e-11
L06 N05 N06 3.38e-11
R06 N05 N06 8.41e+01
C07 N06 N07 1.13e-10
L07 N06 N07 2.82e-12
R07 N06 N07 1.12e+01
C08 N07 Port2 2.88e-12
L08 N07 Port2 5.50e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E130GB12

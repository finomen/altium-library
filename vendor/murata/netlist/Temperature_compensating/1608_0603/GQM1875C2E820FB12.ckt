*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/8.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E820FB12
* Property : C = 8.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E820FB12 Port1 Port2
C01 Port1 N01 8.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.75e-10
R03 N02 N03 4.78e-02
C04 N03 N04 2.13e-10
L04 N03 N04 2.81e-11
R04 N03 N04 1.37e+01
C05 N04 N05 9.45e-11
L05 N04 N05 2.43e-11
R05 N04 N05 1.42e+01
C06 N05 N06 2.16e-10
L06 N05 N06 5.12e-12
R06 N05 N06 4.43e+00
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 7.30e+00
C08 N07 N08 2.29e-10
L08 N07 N08 1.94e-12
R08 N07 N08 2.78e+00
C09 N08 Port2 6.61e-11
L09 N08 Port2 4.86e-12
R09 N08 Port2 1.13e+01
.ENDS GQM1875C2E820FB12

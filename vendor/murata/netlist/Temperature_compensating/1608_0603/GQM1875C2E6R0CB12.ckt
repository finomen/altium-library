*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E6R0CB12
* Property : C = 6.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E6R0CB12 Port1 Port2
C01 Port1 N01 6.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-11
R03 N02 N03 9.00e-02
L04 N03 N04 9.04e-13
R04 N03 N04 6.82e-02
C05 N04 N05 4.96e-12
L05 N04 N05 5.67e-11
C06 N05 N06 1.25e-12
L06 N05 N06 1.63e-10
R06 N05 N06 1.28e+03
C07 N06 Port2 6.24e-12
L07 N06 Port2 7.58e-11
R07 N06 Port2 2.13e+02
.ENDS GQM1875C2E6R0CB12

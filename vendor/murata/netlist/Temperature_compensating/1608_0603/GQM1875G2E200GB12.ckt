*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E200GB12
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E200GB12 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.00e-10
R03 N02 N03 4.19e-02
C04 N03 N04 4.39e-11
L04 N03 N04 3.40e-11
R04 N03 N04 3.45e+01
C05 N04 N05 1.96e-11
L05 N04 N05 3.01e-11
R05 N04 N05 6.32e+01
C06 N05 N06 3.82e-12
L06 N05 N06 6.50e-11
R06 N05 N06 1.00e+05
C07 N06 Port2 1.77e-11
L07 N06 Port2 1.32e-11
R07 N06 Port2 4.74e+00
.ENDS GQM1875G2E200GB12

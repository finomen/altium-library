*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.10e-05[uF]/250[V]
* Murata P/N :GQM1875C2E910JB12
* Property : C = 9.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E910JB12 Port1 Port2
C01 Port1 N01 9.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.63e-10
R03 N02 N03 3.65e-02
C04 N03 N04 1.93e-10
L04 N03 N04 3.71e-11
R04 N03 N04 1.49e+01
C05 N04 N05 1.05e-10
L05 N04 N05 2.51e-11
R05 N04 N05 1.46e+01
C06 N05 N06 1.90e-10
L06 N05 N06 6.87e-12
R06 N05 N06 5.09e+00
C07 N06 N07 8.54e-11
L07 N06 N07 8.98e-12
R07 N06 N07 8.41e+00
C08 N07 N08 1.25e-10
L08 N07 N08 4.09e-12
R08 N07 N08 4.14e+00
C09 N08 Port2 5.08e-11
L09 N08 Port2 7.09e-12
R09 N08 Port2 8.73e+00
.ENDS GQM1875C2E910JB12

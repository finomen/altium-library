*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/5.60e-06[uF]/250[V]
* Murata P/N :GQM1875G2E5R6WB12
* Property : C = 5.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E5R6WB12 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.95e-10
R03 N02 N03 8.50e-02
L04 N03 N04 3.34e-12
R04 N03 N04 1.26e-01
C05 N04 N05 2.82e-12
L05 N04 N05 8.82e-11
C06 N05 Port2 8.43e-12
L06 N05 Port2 5.19e-11
R06 N05 Port2 1.10e+02
.ENDS GQM1875G2E5R6WB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R5DB12
* Property : C = 7.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R5DB12 Port1 Port2
C01 Port1 N01 7.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.30e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.07e-12
R04 N03 N04 4.04e-02
C05 N04 N05 1.53e-12
L05 N04 N05 1.50e-10
C06 N05 N06 1.05e-10
L06 N05 N06 2.97e-12
R06 N05 N06 1.03e+00
C07 N06 Port2 1.28e-11
L07 N06 Port2 4.47e-11
R07 N06 Port2 7.26e+01
.ENDS GQM1875C2E7R5DB12

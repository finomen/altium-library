*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E3R0CB12
* Property : C = 3.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E3R0CB12 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 1.20e-01
L04 N03 N04 9.29e-13
R04 N03 N04 8.76e-02
C05 N04 N05 1.75e-12
L05 N04 N05 1.60e-10
C06 N05 Port2 3.69e-11
L06 N05 Port2 8.38e-12
R06 N05 Port2 2.40e+00
.ENDS GQM1875G2E3R0CB12

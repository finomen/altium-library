*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E560FB12
* Property : C = 5.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E560FB12 Port1 Port2
C01 Port1 N01 5.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.64e-14
R03 N02 N03 5.39e-02
C04 N03 N04 1.35e-10
L04 N03 N04 3.13e-11
R04 N03 N04 1.68e+01
C05 N04 N05 5.58e-11
L05 N04 N05 2.94e-11
R05 N04 N05 2.34e+01
C06 N05 N06 9.39e-11
L06 N05 N06 8.48e-12
R06 N05 N06 9.53e+00
C07 N06 N07 3.31e-11
L07 N06 N07 1.48e-11
R07 N06 N07 2.12e+01
C08 N07 Port2 6.05e-13
L08 N07 Port2 2.54e-10
R08 N07 Port2 7.76e+07
.ENDS GQM1875C2E560FB12

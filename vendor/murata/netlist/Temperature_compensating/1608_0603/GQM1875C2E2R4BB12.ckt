*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.40e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R4BB12
* Property : C = 2.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R4BB12 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.17e-10
R03 N02 N03 1.80e-01
C04 N03 N04 2.33e-12
L04 N03 N04 1.06e-10
C05 N04 Port2 1.26e-10
L05 N04 Port2 2.78e-12
R05 N04 Port2 8.62e-01
.ENDS GQM1875C2E2R4BB12

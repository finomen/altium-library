*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R0DB12
* Property : C = 8.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R0DB12 Port1 Port2
C01 Port1 N01 8.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 4.50e-11
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.24e-12
L06 N05 N06 2.03e-10
C07 N06 N07 1.36e-10
L07 N06 N07 2.86e-12
R07 N06 N07 1.47e+00
C08 N07 N08 1.06e-11
L08 N07 N08 5.69e-11
R08 N07 N08 9.99e+01
C09 N08 Port2 4.05e-09
L09 N08 Port2 2.46e-13
R09 N08 Port2 1.31e-01
.ENDS GQM1875G2E8R0DB12

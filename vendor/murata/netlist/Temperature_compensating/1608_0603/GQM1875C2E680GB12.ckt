*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E680GB12
* Property : C = 6.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E680GB12 Port1 Port2
C01 Port1 N01 6.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.22e-10
R03 N02 N03 5.20e-02
C04 N03 N04 1.67e-10
L04 N03 N04 3.04e-11
R04 N03 N04 1.40e+01
C05 N04 N05 7.07e-11
L05 N04 N05 2.77e-11
R05 N04 N05 1.79e+01
C06 N05 N06 1.14e-10
L06 N05 N06 8.26e-12
R06 N05 N06 5.90e+00
C07 N06 N07 4.78e-11
L07 N06 N07 1.21e-11
R07 N06 N07 1.21e+01
C08 N07 N08 9.96e-11
L08 N07 N08 3.83e-12
R08 N07 N08 5.27e+00
C09 N08 Port2 1.36e-12
L09 N08 Port2 1.57e-10
R09 N08 Port2 1.58e+08
.ENDS GQM1875C2E680GB12

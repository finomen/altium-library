*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/6.20e-05[uF]/250[V]
* Murata P/N :GQM1875C2E620JB12
* Property : C = 6.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E620JB12 Port1 Port2
C01 Port1 N01 6.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.83e-10
R03 N02 N03 4.61e-02
C04 N03 N04 1.56e-10
L04 N03 N04 3.04e-11
R04 N03 N04 1.71e+01
C05 N04 N05 6.90e-11
L05 N04 N05 2.63e-11
R05 N04 N05 1.73e+01
C06 N05 N06 1.31e-10
L06 N05 N06 6.79e-12
R06 N05 N06 6.38e+00
C07 N06 N07 6.92e-11
L07 N06 N07 7.76e-12
R07 N06 N07 9.13e+00
C08 N07 Port2 8.57e-11
L08 N07 Port2 4.19e-12
R08 N07 Port2 4.32e+00
.ENDS GQM1875C2E620JB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E7R0CB12
* Property : C = 7.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E7R0CB12 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 7.50e-02
L04 N03 N04 1.08e-11
R04 N03 N04 2.03e+00
C05 N04 N05 1.90e-12
L05 N04 N05 1.42e-10
C06 N05 N06 1.38e-10
L06 N05 N06 2.86e-12
R06 N05 N06 1.21e+00
C07 N06 N07 1.03e-11
L07 N06 N07 5.43e-11
R07 N06 N07 1.19e+02
C08 N07 Port2 3.55e-09
L08 N07 Port2 2.75e-13
R08 N07 Port2 1.12e-01
.ENDS GQM1875C2E7R0CB12

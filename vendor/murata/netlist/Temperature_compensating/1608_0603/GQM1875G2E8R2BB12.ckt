*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/8.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E8R2BB12
* Property : C = 8.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E8R2BB12 Port1 Port2
C01 Port1 N01 8.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.46e-10
R03 N02 N03 7.00e-02
L04 N03 N04 1.27e-12
R04 N03 N04 3.18e-02
C05 N04 N05 1.88e-12
L05 N04 N05 1.29e-10
C06 N05 N06 2.46e-11
L06 N05 N06 1.14e-11
R06 N05 N06 6.46e+00
C07 N06 Port2 1.47e-11
L07 N06 Port2 4.20e-11
R07 N06 Port2 6.75e+01
.ENDS GQM1875G2E8R2BB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.80e-05[uF]/250[V]
* Murata P/N :GQM1875C2E180GB12
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E180GB12 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.29e-10
R03 N02 N03 4.50e-02
C04 N03 N04 4.08e-11
L04 N03 N04 3.39e-11
R04 N03 N04 4.69e+01
C05 N04 N05 1.36e-11
L05 N04 N05 3.98e-11
R05 N04 N05 9.18e+01
C06 N05 N06 5.21e-11
L06 N05 N06 4.50e-12
R06 N05 N06 1.02e+00
C07 N06 Port2 1.59e-12
L07 N06 Port2 1.40e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875C2E180GB12

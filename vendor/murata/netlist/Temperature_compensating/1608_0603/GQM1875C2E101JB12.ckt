*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-04[uF]/250[V]
* Murata P/N :GQM1875C2E101JB12
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E101JB12 Port1 Port2
C01 Port1 N01 1.00e-10
R01 Port1 N01 1.00e+10
L02 N01 N02 1.27e-10
R03 N02 N03 4.70e-02
C04 N03 N04 1.94e-12
L04 N03 N04 1.28e-10
C05 N04 N05 2.08e-10
L05 N04 N05 3.56e-11
R05 N04 N05 1.26e+01
C06 N05 N06 1.03e-10
L06 N05 N06 2.72e-11
R06 N05 N06 1.40e+01
C07 N06 N07 2.02e-10
L07 N06 N07 6.76e-12
R07 N06 N07 4.89e+00
C08 N07 N08 7.46e-11
L08 N07 N08 1.10e-11
R08 N07 N08 8.80e+00
C09 N08 N09 1.27e-10
L09 N08 N09 4.27e-12
R09 N08 N09 4.01e+00
C10 N09 Port2 4.33e-11
L10 N09 Port2 8.92e-12
R10 N09 Port2 1.01e+01
.ENDS GQM1875C2E101JB12

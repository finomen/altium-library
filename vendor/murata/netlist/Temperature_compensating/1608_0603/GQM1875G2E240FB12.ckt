*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.40e-05[uF]/250[V]
* Murata P/N :GQM1875G2E240FB12
* Property : C = 2.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E240FB12 Port1 Port2
C01 Port1 N01 2.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.08e-10
R03 N02 N03 4.17e-02
L04 N03 N04 3.88e-12
R04 N03 N04 4.33e-02
C05 N04 N05 6.05e-11
L05 N04 N05 3.00e-11
R05 N04 N05 3.16e+01
C06 N05 N06 2.31e-11
L06 N05 N06 3.06e-11
R06 N05 N06 4.78e+01
C07 N06 N07 1.32e-11
L07 N06 N07 2.62e-11
R07 N06 N07 4.54e+01
C08 N07 Port2 5.16e-12
L08 N07 Port2 4.78e-11
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E240FB12

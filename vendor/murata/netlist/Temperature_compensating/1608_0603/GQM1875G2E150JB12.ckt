*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.50e-05[uF]/250[V]
* Murata P/N :GQM1875G2E150JB12
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E150JB12 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 6.67e-11
R03 N02 N03 5.14e-02
L04 N03 N04 4.00e-12
R04 N03 N04 4.61e-02
C05 N04 N05 3.32e-11
L05 N04 N05 3.46e-11
R05 N04 N05 5.11e+01
C06 N05 N06 8.65e-12
L06 N05 N06 5.37e-11
R06 N05 N06 1.56e+02
C07 N06 Port2 1.30e-12
L07 N06 Port2 1.74e-10
R07 N06 Port2 1.00e+05
.ENDS GQM1875G2E150JB12

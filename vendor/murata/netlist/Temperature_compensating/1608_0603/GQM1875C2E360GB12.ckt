*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.60e-05[uF]/250[V]
* Murata P/N :GQM1875C2E360GB12
* Property : C = 3.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E360GB12 Port1 Port2
C01 Port1 N01 3.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.11e-10
R03 N02 N03 3.96e-02
L04 N03 N04 9.17e-12
R04 N03 N04 1.92e-02
C05 N04 N05 8.47e-11
L05 N04 N05 3.28e-11
R05 N04 N05 2.32e+01
C06 N05 N06 3.85e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.61e+01
C07 N06 N07 7.33e-11
L07 N06 N07 7.24e-12
R07 N06 N07 9.34e+00
C08 N07 N08 2.63e-11
L08 N07 N08 1.24e-11
R08 N07 N08 2.40e+01
C09 N08 Port2 2.88e-12
L09 N08 Port2 6.10e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E360GB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/9.10e-06[uF]/250[V]
* Murata P/N :GQM1875G2E9R1DB12
* Property : C = 9.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E9R1DB12 Port1 Port2
C01 Port1 N01 9.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.82e-10
R03 N02 N03 8.02e-02
C04 N03 N04 1.73e-11
L04 N03 N04 4.06e-11
R04 N03 N04 7.99e+01
C05 N04 N05 1.97e-11
L05 N04 N05 1.60e-11
R05 N04 N05 2.83e+01
C06 N05 Port2 2.35e-12
L06 N05 Port2 1.00e-10
R06 N05 Port2 2.27e+02
.ENDS GQM1875G2E9R1DB12

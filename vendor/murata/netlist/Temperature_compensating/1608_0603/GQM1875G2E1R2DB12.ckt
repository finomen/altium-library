*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R2DB12
* Property : C = 1.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R2DB12 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.31e-10
R03 N02 N03 2.60e-01
C04 N03 N04 1.36e-11
L04 N03 N04 1.83e-11
C05 N04 Port2 2.13e-09
L05 N04 Port2 1.57e-13
R05 N04 Port2 7.26e-02
.ENDS GQM1875G2E1R2DB12

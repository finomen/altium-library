*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.30e-05[uF]/250[V]
* Murata P/N :GQM1875C2E430JB12
* Property : C = 4.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E430JB12 Port1 Port2
C01 Port1 N01 4.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.80e-10
R03 N02 N03 3.88e-02
L04 N03 N04 7.18e-12
R04 N03 N04 1.80e-02
C05 N04 N05 1.04e-10
L05 N04 N05 3.16e-11
R05 N04 N05 2.24e+01
C06 N05 N06 4.71e-11
L06 N05 N06 2.74e-11
R06 N05 N06 2.74e+01
C07 N06 N07 8.17e-11
L07 N06 N07 7.71e-12
R07 N06 N07 9.84e+00
C08 N07 N08 2.46e-11
L08 N07 N08 1.61e-11
R08 N07 N08 2.66e+01
C09 N08 N09 5.12e-12
L09 N08 N09 4.95e-11
R09 N08 N09 1.00e+05
C10 N09 Port2 5.74e-12
L10 N09 Port2 4.14e-11
R10 N09 Port2 3.55e+01
.ENDS GQM1875C2E430JB12

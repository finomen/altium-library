*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/3.90e-05[uF]/250[V]
* Murata P/N :GQM1875C2E390GB12
* Property : C = 3.90e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E390GB12 Port1 Port2
C01 Port1 N01 3.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 3.00e-02
L04 N03 N04 5.48e-12
R04 N03 N04 3.44e-02
C05 N04 N05 1.17e-10
L05 N04 N05 2.55e-11
R05 N04 N05 1.94e+01
C06 N05 N06 4.09e-11
L06 N05 N06 2.81e-11
R06 N05 N06 2.80e+01
C07 N06 N07 6.70e-11
L07 N06 N07 8.43e-12
R07 N06 N07 1.13e+01
C08 N07 N08 1.69e-11
L08 N07 N08 2.03e-11
R08 N07 N08 4.01e+01
C09 N08 Port2 1.67e-12
L09 N08 Port2 1.21e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E390GB12

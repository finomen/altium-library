*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E270JB12
* Property : C = 2.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E270JB12 Port1 Port2
C01 Port1 N01 2.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.81e-11
R03 N02 N03 3.97e-02
L04 N03 N04 4.32e-12
R04 N03 N04 4.70e-02
C05 N04 N05 6.64e-11
L05 N04 N05 2.96e-11
R05 N04 N05 2.11e+01
C06 N05 N06 2.36e-11
L06 N05 N06 3.29e-11
R06 N05 N06 3.57e+01
C07 N06 N07 3.78e-11
L07 N06 N07 9.96e-12
R07 N06 N07 2.17e+01
C08 N07 Port2 7.57e-13
L08 N07 Port2 2.33e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875C2E270JB12

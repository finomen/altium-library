*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.10e-05[uF]/250[V]
* Murata P/N :GQM1875C2E110JB12
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E110JB12 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.64e-10
R03 N02 N03 7.60e-02
L04 N03 N04 1.54e-12
R04 N03 N04 2.61e-02
C05 N04 N05 2.56e-11
L05 N04 N05 3.30e-11
R05 N04 N05 5.05e+01
C06 N05 Port2 6.65e-12
L06 N05 Port2 5.09e-11
R06 N05 Port2 1.20e+02
.ENDS GQM1875C2E110JB12

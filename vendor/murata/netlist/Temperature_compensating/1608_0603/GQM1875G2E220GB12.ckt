*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.20e-05[uF]/250[V]
* Murata P/N :GQM1875G2E220GB12
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E220GB12 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 4.00e-02
L04 N03 N04 4.45e-12
R04 N03 N04 3.47e-02
C05 N04 N05 5.30e-11
L05 N04 N05 3.11e-11
R05 N04 N05 2.80e+01
C06 N05 N06 1.87e-11
L06 N05 N06 3.45e-11
R06 N05 N06 5.45e+01
C07 N06 N07 3.08e-11
L07 N06 N07 1.03e-11
R07 N06 N07 6.50e+00
C08 N07 Port2 1.98e-12
L08 N07 Port2 1.20e-10
R08 N07 Port2 1.00e+05
.ENDS GQM1875G2E220GB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/3.00e-05[uF]/250[V]
* Murata P/N :GQM1875G2E300FB12
* Property : C = 3.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E300FB12 Port1 Port2
C01 Port1 N01 3.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.38e-10
R03 N02 N03 4.08e-02
L04 N03 N04 9.33e-12
R04 N03 N04 2.28e-02
C05 N04 N05 7.31e-11
L05 N04 N05 3.06e-11
R05 N04 N05 2.54e+01
C06 N05 N06 3.04e-11
L06 N05 N06 2.85e-11
R06 N05 N06 3.46e+01
C07 N06 N07 6.29e-11
L07 N06 N07 6.68e-12
R07 N06 N07 1.10e+01
C08 N07 N08 8.11e-11
L08 N07 N08 3.60e-12
R08 N07 N08 8.90e+00
C09 N08 Port2 6.26e-12
L09 N08 Port2 3.85e-11
R09 N08 Port2 1.00e+05
.ENDS GQM1875G2E300FB12

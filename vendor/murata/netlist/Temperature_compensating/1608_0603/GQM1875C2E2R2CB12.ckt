*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/2.20e-06[uF]/250[V]
* Murata P/N :GQM1875C2E2R2CB12
* Property : C = 2.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E2R2CB12 Port1 Port2
C01 Port1 N01 2.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.70e-01
C04 N03 N04 1.65e-12
L04 N03 N04 1.40e-10
C05 N04 Port2 7.55e-11
L05 N04 Port2 3.95e-12
R05 N04 Port2 1.41e+00
.ENDS GQM1875C2E2R2CB12

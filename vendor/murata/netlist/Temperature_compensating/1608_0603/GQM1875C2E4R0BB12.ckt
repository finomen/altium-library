*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E4R0BB12
* Property : C = 4.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E4R0BB12 Port1 Port2
C01 Port1 N01 4.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.05e-01
L04 N03 N04 1.89e-12
R04 N03 N04 1.78e-01
C05 N04 N05 1.90e-12
L05 N04 N05 1.55e-10
C06 N05 Port2 2.50e-11
L06 N05 Port2 1.30e-11
R06 N05 Port2 8.12e+00
.ENDS GQM1875C2E4R0BB12

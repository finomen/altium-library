*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/5.10e-06[uF]/250[V]
* Murata P/N :GQM1875C2E5R1CB12
* Property : C = 5.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E5R1CB12 Port1 Port2
C01 Port1 N01 5.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.70e-10
R03 N02 N03 9.00e-02
L04 N03 N04 2.65e-12
R04 N03 N04 1.25e-01
C05 N04 N05 1.21e-11
L05 N04 N05 2.47e-11
C06 N05 Port2 7.50e-12
L06 N05 Port2 5.42e-11
R06 N05 Port2 1.34e+02
.ENDS GQM1875C2E5R1CB12

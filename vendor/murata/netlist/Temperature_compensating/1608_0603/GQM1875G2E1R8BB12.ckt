*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/1.80e-06[uF]/250[V]
* Murata P/N :GQM1875G2E1R8BB12
* Property : C = 1.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E1R8BB12 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 3.02e-10
R03 N02 N03 2.00e-01
C04 N03 N04 7.42e-12
L04 N03 N04 3.35e-11
C05 N04 Port2 7.34e-10
L05 N04 Port2 4.78e-13
R05 N04 Port2 1.02e-01
.ENDS GQM1875G2E1R8BB12

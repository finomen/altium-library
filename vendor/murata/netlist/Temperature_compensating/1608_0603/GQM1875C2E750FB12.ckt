*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/7.50e-05[uF]/250[V]
* Murata P/N :GQM1875C2E750FB12
* Property : C = 7.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E750FB12 Port1 Port2
C01 Port1 N01 7.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 2.79e-10
R03 N02 N03 4.31e-02
C04 N03 N04 1.63e-10
L04 N03 N04 3.58e-11
R04 N03 N04 1.63e+01
C05 N04 N05 8.38e-11
L05 N04 N05 2.57e-11
R05 N04 N05 1.74e+01
C06 N05 N06 1.60e-10
L06 N05 N06 6.53e-12
R06 N05 N06 5.37e+00
C07 N06 N07 7.78e-11
L07 N06 N07 8.22e-12
R07 N06 N07 9.24e+00
C08 N07 Port2 1.23e-10
L08 N07 Port2 3.45e-12
R08 N07 Port2 3.94e+00
.ENDS GQM1875C2E750FB12

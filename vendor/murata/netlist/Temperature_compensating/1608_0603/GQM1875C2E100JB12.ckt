*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/1.00e-05[uF]/250[V]
* Murata P/N :GQM1875C2E100JB12
* Property : C = 1.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E100JB12 Port1 Port2
C01 Port1 N01 1.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 8.00e-02
C04 N03 N04 1.63e-11
L04 N03 N04 4.82e-11
R04 N03 N04 1.02e+02
C05 N04 N05 2.08e-11
L05 N04 N05 1.58e-11
R05 N04 N05 8.63e+00
C06 N05 Port2 2.77e-12
L06 N05 Port2 1.18e-10
R06 N05 Port2 1.00e+05
.ENDS GQM1875C2E100JB12

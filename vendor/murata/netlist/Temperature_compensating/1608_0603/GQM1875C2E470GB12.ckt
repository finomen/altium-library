*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/4.70e-05[uF]/250[V]
* Murata P/N :GQM1875C2E470GB12
* Property : C = 4.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E470GB12 Port1 Port2
C01 Port1 N01 4.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 8.42e-11
R03 N02 N03 3.20e-02
L04 N03 N04 6.62e-11
R04 N03 N04 1.34e+01
C05 N04 N05 1.14e-10
L05 N04 N05 3.12e-11
R05 N04 N05 1.86e+01
C06 N05 N06 4.96e-11
L06 N05 N06 2.79e-11
R06 N05 N06 2.38e+01
C07 N06 N07 1.08e-10
L07 N06 N07 6.24e-12
R07 N06 N07 9.46e+00
C08 N07 N08 3.07e-11
L08 N07 N08 1.36e-11
R08 N07 N08 2.58e+01
C09 N08 Port2 2.04e-12
L09 N08 Port2 1.16e-10
R09 N08 Port2 1.00e+05
.ENDS GQM1875C2E470GB12

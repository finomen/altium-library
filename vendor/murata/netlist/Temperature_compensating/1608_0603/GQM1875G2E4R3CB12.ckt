*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/4.30e-06[uF]/250[V]
* Murata P/N :GQM1875G2E4R3CB12
* Property : C = 4.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E4R3CB12 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 5.26e-12
R04 N03 N04 3.31e-02
C05 N04 N05 2.69e-12
L05 N04 N05 1.11e-10
C06 N05 Port2 5.94e-12
L06 N05 Port2 5.97e-11
R06 N05 Port2 1.21e+02
.ENDS GQM1875G2E4R3CB12

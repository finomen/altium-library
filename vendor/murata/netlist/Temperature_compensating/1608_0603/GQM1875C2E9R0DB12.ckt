*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/C0G(-55to125[deg])/9.00e-06[uF]/250[V]
* Murata P/N :GQM1875C2E9R0DB12
* Property : C = 9.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875C2E9R0DB12 Port1 Port2
C01 Port1 N01 9.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.17e-10
R03 N02 N03 6.70e-02
L04 N03 N04 1.15e-12
R04 N03 N04 7.23e-02
L05 N04 N05 5.25e-12
R05 N04 N05 9.89e-01
C06 N05 N06 1.78e-12
L06 N05 N06 1.63e-10
R06 N05 N06 8.93e+02
C07 N06 Port2 1.51e-11
L07 N06 Port2 4.74e-11
R07 N06 Port2 1.06e+02
.ENDS GQM1875C2E9R0DB12

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/2.00e-06[uF]/250[V]
* Murata P/N :GQM1875G2E2R0DB12
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E2R0DB12 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.72e-10
R03 N02 N03 1.90e-01
C04 N03 N04 1.70e-12
L04 N03 N04 1.30e-10
C05 N04 Port2 6.31e-11
L05 N04 Port2 4.71e-12
R05 N04 Port2 2.29e+00
.ENDS GQM1875G2E2R0DB12

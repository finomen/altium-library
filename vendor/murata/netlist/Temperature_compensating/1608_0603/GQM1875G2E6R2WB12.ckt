*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1608M(0603)/X8G(-55to150[deg])/6.20e-06[uF]/250[V]
* Murata P/N :GQM1875G2E6R2WB12
* Property : C = 6.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-9[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GQM1875G2E6R2WB12 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 2.16e-10
R03 N02 N03 8.00e-02
L04 N03 N04 4.66e-12
R04 N03 N04 8.77e-02
C05 N04 N05 3.51e-12
L05 N04 N05 7.08e-11
C06 N05 Port2 1.14e-11
L06 N05 Port2 4.08e-11
R06 N05 Port2 1.07e+02
.ENDS GQM1875G2E6R2WB12

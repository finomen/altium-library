*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.00e-06[uF]/25[V]
* Murata P/N :GJM0225C1E2R0WB01
* Property : C = 2.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E2R0WB01 Port1 Port2
C01 Port1 N01 2.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.38e-10
R03 N02 N03 1.87e-01
L04 N03 N04 1.23e-12
R04 N03 N04 3.85e-02
C05 N04 N05 1.81e-11
L05 N04 N05 2.74e-12
R05 N04 N05 7.08e+00
C06 N05 N06 2.73e-12
L06 N05 N06 8.64e-12
R06 N05 N06 2.63e+01
C07 N06 Port2 1.30e-12
L07 N06 Port2 5.94e-12
R07 N06 Port2 3.42e+01
.ENDS GJM0225C1E2R0WB01

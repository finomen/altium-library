*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/8.60e-06[uF]/16[V]
* Murata P/N :GJM0225C1C8R6BB01
* Property : C = 8.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C8R6BB01 Port1 Port2
C01 Port1 N01 8.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 9.00e-02
L04 N03 N04 4.54e-12
R04 N03 N04 6.37e-02
C05 N04 N05 1.57e-10
L05 N04 N05 1.18e-12
R05 N04 N05 1.27e+00
C06 N05 N06 1.37e-11
L06 N05 N06 5.28e-12
R06 N05 N06 7.63e+00
C07 N06 N07 8.66e-11
L07 N06 N07 3.49e-13
R07 N06 N07 7.63e-01
C08 N07 N08 5.41e-12
L08 N07 N08 3.79e-12
R08 N07 N08 8.76e+00
C09 N08 Port2 7.16e-12
L09 N08 Port2 1.91e-12
R09 N08 Port2 6.96e+00
.ENDS GJM0225C1C8R6BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.60e-05[uF]/25[V]
* Murata P/N :GJM0225G1E160JB01
* Property : C = 1.60e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E160JB01 Port1 Port2
C01 Port1 N01 1.60e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.51e-10
R03 N02 N03 7.91e-02
L04 N03 N04 5.96e-12
R04 N03 N04 8.40e-02
C05 N04 N05 2.09e-10
L05 N04 N05 2.01e-12
R05 N04 N05 1.19e+00
C06 N05 N06 2.75e-11
L06 N05 N06 6.46e-12
R06 N05 N06 4.61e+00
C07 N06 N07 3.16e-11
L07 N06 N07 1.89e-12
R07 N06 N07 1.84e+00
C08 N07 N08 1.07e-10
L08 N07 N08 3.95e-13
R08 N07 N08 5.18e-01
C09 N08 Port2 8.48e-12
L09 N08 Port2 3.49e-12
R09 N08 Port2 3.93e+00
.ENDS GJM0225G1E160JB01

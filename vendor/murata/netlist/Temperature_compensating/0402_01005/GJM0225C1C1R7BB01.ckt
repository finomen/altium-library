*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.70e-06[uF]/16[V]
* Murata P/N :GJM0225C1C1R7BB01
* Property : C = 1.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C1R7BB01 Port1 Port2
C01 Port1 N01 1.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 2.16e-01
L04 N03 N04 5.44e-13
R04 N03 N04 3.92e-02
C05 N04 N05 2.92e-11
L05 N04 N05 1.46e-12
R05 N04 N05 5.25e+00
C06 N05 N06 1.23e-10
L06 N05 N06 2.45e-13
R06 N05 N06 4.57e-01
C07 N06 N07 3.19e-12
L07 N06 N07 6.38e-12
R07 N06 N07 2.57e+01
C08 N07 N08 1.59e-11
L08 N07 N08 8.34e-13
R08 N07 N08 3.09e+00
C09 N08 Port2 6.50e-12
L09 N08 Port2 1.79e-12
R09 N08 Port2 8.32e+00
.ENDS GJM0225C1C1R7BB01

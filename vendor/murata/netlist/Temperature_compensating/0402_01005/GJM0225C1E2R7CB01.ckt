*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.70e-06[uF]/25[V]
* Murata P/N :GJM0225C1E2R7CB01
* Property : C = 2.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E2R7CB01 Port1 Port2
C01 Port1 N01 2.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.14e-01
L04 N03 N04 3.79e-13
R04 N03 N04 1.40e-02
C05 N04 N05 6.47e-11
L05 N04 N05 7.86e-13
R05 N04 N05 1.56e+00
C06 N05 N06 5.07e-12
L06 N05 N06 4.59e-12
R06 N05 N06 1.38e+01
C07 N06 N07 3.60e-12
L07 N06 N07 5.80e-12
R07 N06 N07 7.39e+00
C08 N07 Port2 1.12e-11
L08 N07 Port2 1.23e-12
R08 N07 Port2 4.16e+00
.ENDS GJM0225C1E2R7CB01

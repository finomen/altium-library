*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/2.80e-06[uF]/25[V]
* Murata P/N :GJM0225G1E2R8BB01
* Property : C = 2.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E2R8BB01 Port1 Port2
C01 Port1 N01 2.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.67e-10
R03 N02 N03 2.13e-01
L04 N03 N04 7.39e-13
R04 N03 N04 2.73e-02
C05 N04 N05 6.40e-11
L05 N04 N05 8.55e-13
R05 N04 N05 1.63e+00
C06 N05 N06 3.37e-12
L06 N05 N06 7.15e-12
R06 N05 N06 1.75e+01
C07 N06 N07 3.26e-11
L07 N06 N07 5.00e-13
R07 N06 N07 1.52e+00
C08 N07 Port2 2.15e-11
L08 N07 Port2 6.30e-13
R08 N07 Port2 2.15e+00
.ENDS GJM0225G1E2R8BB01

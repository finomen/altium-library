*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/8.30e-06[uF]/25[V]
* Murata P/N :GJM0225G1E8R3BB01
* Property : C = 8.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E8R3BB01 Port1 Port2
C01 Port1 N01 8.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 9.00e-02
L04 N03 N04 4.24e-12
R04 N03 N04 5.94e-02
C05 N04 N05 1.20e-10
L05 N04 N05 1.53e-12
R05 N04 N05 1.63e+00
C06 N05 N06 9.07e-12
L06 N05 N06 8.00e-12
R06 N05 N06 8.76e+00
C07 N06 N07 6.87e-11
L07 N06 N07 4.81e-13
R07 N06 N07 1.01e+00
C08 N07 N08 2.53e-12
L08 N07 N08 8.48e-12
R08 N07 N08 1.92e+01
C09 N08 Port2 1.72e-11
L09 N08 Port2 7.95e-13
R09 N08 Port2 2.90e+00
.ENDS GJM0225G1E8R3BB01

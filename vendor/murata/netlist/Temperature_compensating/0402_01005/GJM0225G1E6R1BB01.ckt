*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/6.10e-06[uF]/25[V]
* Murata P/N :GJM0225G1E6R1BB01
* Property : C = 6.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E6R1BB01 Port1 Port2
C01 Port1 N01 6.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.30e-01
L04 N03 N04 3.24e-12
R04 N03 N04 5.24e-02
C05 N04 N05 1.79e-10
L05 N04 N05 6.54e-13
R05 N04 N05 8.26e-01
C06 N05 N06 9.10e-11
L06 N05 N06 7.95e-13
R06 N05 N06 2.40e-01
C07 N06 N07 1.03e-11
L07 N06 N07 4.33e-12
R07 N06 N07 8.02e+00
C08 N07 N08 9.87e-11
L08 N07 N08 2.95e-13
R08 N07 N08 3.03e-01
C09 N08 N09 4.18e-11
L09 N08 N09 5.46e-13
R09 N08 N09 7.45e-01
C10 N09 N10 1.13e-11
L10 N09 N10 1.28e-12
R10 N09 N10 3.91e+00
C11 N10 Port2 2.75e-11
L11 N10 Port2 3.75e-13
R11 N10 Port2 2.13e+00
.ENDS GJM0225G1E6R1BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/9.00e-07[uF]/16[V]
* Murata P/N :GJM0225C1CR90BB01
* Property : C = 9.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1CR90BB01 Port1 Port2
C01 Port1 N01 9.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 2.27e-01
C04 N03 N04 7.34e-11
L04 N03 N04 3.27e-13
R04 N03 N04 1.29e+00
C05 N04 N05 1.52e-11
L05 N04 N05 1.32e-12
R05 N04 N05 4.05e+00
C06 N05 N06 1.86e-12
L06 N05 N06 7.05e-12
R06 N05 N06 3.08e+01
C07 N06 Port2 1.24e-12
L07 N06 Port2 5.18e-12
R07 N06 Port2 3.26e+01
.ENDS GJM0225C1CR90BB01

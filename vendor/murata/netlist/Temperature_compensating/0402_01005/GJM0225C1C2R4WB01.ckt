*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.40e-06[uF]/16[V]
* Murata P/N :GJM0225C1C2R4WB01
* Property : C = 2.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C2R4WB01 Port1 Port2
C01 Port1 N01 2.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.85e-01
L04 N03 N04 6.90e-13
R04 N03 N04 2.38e-02
C05 N04 N05 3.49e-11
L05 N04 N05 1.72e-12
R05 N04 N05 4.75e+00
C06 N05 N06 4.50e-12
L06 N05 N06 6.11e-12
R06 N05 N06 1.85e+01
C07 N06 Port2 4.34e-12
L07 N06 Port2 3.23e-12
R07 N06 Port2 5.20e+00
.ENDS GJM0225C1C2R4WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.90e-05[uF]/25[V]
* Murata P/N :GJM0225G1E190JB01
* Property : C = 1.90e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E190JB01 Port1 Port2
C01 Port1 N01 1.90e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 6.07e-02
L04 N03 N04 8.71e-12
R04 N03 N04 6.89e-02
C05 N04 N05 3.34e-10
L05 N04 N05 1.49e-12
R05 N04 N05 9.39e-01
C06 N05 N06 3.34e-11
L06 N05 N06 6.37e-12
R06 N05 N06 4.58e+00
C07 N06 N07 2.52e-10
L07 N06 N07 4.31e-13
R07 N06 N07 3.17e-01
C08 N07 N08 3.76e-11
L08 N07 N08 1.79e-12
R08 N07 N08 1.91e+00
C09 N08 N09 2.85e-10
L09 N08 N09 1.50e-13
R09 N08 N09 2.52e-01
C10 N09 Port2 1.78e-11
L10 N09 Port2 1.80e-12
R10 N09 Port2 1.78e+00
.ENDS GJM0225G1E190JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.10e-05[uF]/25[V]
* Murata P/N :GJM0225G1E110GB01
* Property : C = 1.10e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E110GB01 Port1 Port2
C01 Port1 N01 1.10e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 8.31e-02
L04 N03 N04 1.12e-11
R04 N03 N04 8.58e-02
L05 N04 N05 1.43e-12
R05 N04 N05 4.26e-02
C06 N05 N06 2.63e-10
L06 N05 N06 1.03e-12
R06 N05 N06 7.93e-01
C07 N06 N07 1.93e-11
L07 N06 N07 5.95e-12
R07 N06 N07 5.28e+00
C08 N07 N08 4.70e-09
L08 N07 N08 1.28e-14
R08 N07 N08 2.90e-02
C09 N08 N09 2.05e-11
L09 N08 N09 1.92e-12
R09 N08 N09 2.47e+00
C10 N09 Port2 2.05e-11
L10 N09 Port2 1.40e-12
R10 N09 Port2 2.01e+00
.ENDS GJM0225G1E110GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/8.10e-06[uF]/16[V]
* Murata P/N :GJM0225C1C8R1BB01
* Property : C = 8.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C8R1BB01 Port1 Port2
C01 Port1 N01 8.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 9.00e-02
L04 N03 N04 4.14e-12
R04 N03 N04 9.21e-02
C05 N04 N05 1.46e-10
L05 N04 N05 1.25e-12
R05 N04 N05 1.47e+00
C06 N05 N06 1.36e-11
L06 N05 N06 5.33e-12
R06 N05 N06 7.35e+00
C07 N06 N07 7.45e-11
L07 N06 N07 4.21e-13
R07 N06 N07 4.23e-01
C08 N07 N08 3.39e-12
L08 N07 N08 5.92e-12
R08 N07 N08 9.04e+00
C09 N08 Port2 3.00e-11
L09 N08 Port2 4.46e-13
R09 N08 Port2 1.85e+00
.ENDS GJM0225C1C8R1BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/3.00e-06[uF]/25[V]
* Murata P/N :GJM0225G1E3R0BB01
* Property : C = 3.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E3R0BB01 Port1 Port2
C01 Port1 N01 3.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.63e-10
R03 N02 N03 2.13e-01
L04 N03 N04 3.15e-13
R04 N03 N04 1.16e-02
C05 N04 N05 4.87e-11
L05 N04 N05 1.20e-12
R05 N04 N05 2.17e+00
C06 N05 N06 4.77e-12
L06 N05 N06 5.37e-12
R06 N05 N06 1.31e+01
C07 N06 N07 2.99e-12
L07 N06 N07 6.42e-12
R07 N06 N07 1.31e+01
C08 N07 Port2 6.58e-12
L08 N07 Port2 2.14e-12
R08 N07 Port2 5.32e+00
.ENDS GJM0225G1E3R0BB01

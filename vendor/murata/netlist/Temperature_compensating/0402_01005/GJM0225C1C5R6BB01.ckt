*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/5.60e-06[uF]/16[V]
* Murata P/N :GJM0225C1C5R6BB01
* Property : C = 5.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C5R6BB01 Port1 Port2
C01 Port1 N01 5.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 1.47e-01
L04 N03 N04 6.78e-13
R04 N03 N04 2.75e-02
C05 N04 N05 9.24e-11
L05 N04 N05 1.41e-12
R05 N04 N05 1.69e+00
C06 N05 N06 1.26e-10
L06 N05 N06 6.93e-13
R06 N05 N06 1.91e-01
C07 N06 N07 9.80e-12
L07 N06 N07 5.71e-12
R07 N06 N07 9.42e+00
C08 N07 N08 4.62e-11
L08 N07 N08 6.61e-13
R08 N07 N08 1.05e+00
C09 N08 N09 1.12e-11
L09 N08 N09 2.03e-12
R09 N08 N09 4.00e+00
C10 N09 N10 8.03e-12
L10 N09 N10 2.09e-12
R10 N09 N10 4.09e+00
C11 N10 Port2 4.62e-12
L11 N10 Port2 2.19e-12
R11 N10 Port2 1.07e+01
.ENDS GJM0225C1C5R6BB01

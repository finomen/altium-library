*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.50e-05[uF]/25[V]
* Murata P/N :GJM0225G1E150GB01
* Property : C = 1.50e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E150GB01 Port1 Port2
C01 Port1 N01 1.50e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 7.94e-02
L04 N03 N04 5.38e-12
R04 N03 N04 1.06e-01
C05 N04 N05 1.93e-10
L05 N04 N05 1.93e-12
R05 N04 N05 1.40e+00
C06 N05 N06 2.40e-11
L06 N05 N06 6.49e-12
R06 N05 N06 5.40e+00
C07 N06 N07 2.57e-11
L07 N06 N07 1.94e-12
R07 N06 N07 2.05e+00
C08 N07 Port2 1.27e-11
L08 N07 Port2 2.15e-12
R08 N07 Port2 2.36e+00
.ENDS GJM0225G1E150GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.70e-05[uF]/25[V]
* Murata P/N :GJM0225G1E170JB01
* Property : C = 1.70e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E170JB01 Port1 Port2
C01 Port1 N01 1.70e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 7.82e-02
L04 N03 N04 5.45e-12
R04 N03 N04 6.46e-02
C05 N04 N05 2.01e-10
L05 N04 N05 2.18e-12
R05 N04 N05 1.39e+00
C06 N05 N06 2.75e-11
L06 N05 N06 6.82e-12
R06 N05 N06 5.14e+00
C07 N06 N07 2.60e-10
L07 N06 N07 3.79e-13
R07 N06 N07 3.39e-01
C08 N07 N08 3.48e-11
L08 N07 N08 1.75e-12
R08 N07 N08 2.00e+00
C09 N08 N09 1.34e-10
L09 N08 N09 3.15e-13
R09 N08 N09 4.37e-01
C10 N09 Port2 1.75e-11
L10 N09 Port2 1.71e-12
R10 N09 Port2 2.40e+00
.ENDS GJM0225G1E170JB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.30e-06[uF]/25[V]
* Murata P/N :GJM0225G1E1R3WB01
* Property : C = 1.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E1R3WB01 Port1 Port2
C01 Port1 N01 1.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.60e-10
R03 N02 N03 2.89e-01
C04 N03 N04 2.63e-11
L04 N03 N04 1.10e-12
R04 N03 N04 3.09e+00
C05 N04 N05 1.77e-11
L05 N04 N05 1.12e-12
R05 N04 N05 5.01e+00
C06 N05 N06 2.30e-12
L06 N05 N06 6.63e-12
R06 N05 N06 2.04e+01
C07 N06 N07 1.05e-11
L07 N06 N07 1.15e-12
R07 N06 N07 6.61e+00
C08 N07 Port2 2.52e-12
L08 N07 Port2 4.18e-12
R08 N07 Port2 2.88e+01
.ENDS GJM0225G1E1R3WB01

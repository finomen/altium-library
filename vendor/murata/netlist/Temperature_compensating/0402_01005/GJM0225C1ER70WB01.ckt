*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/7.00e-07[uF]/25[V]
* Murata P/N :GJM0225C1ER70WB01
* Property : C = 7.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1ER70WB01 Port1 Port2
C01 Port1 N01 7.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.11e-10
R03 N02 N03 2.44e-01
C04 N03 N04 8.27e-12
L04 N03 N04 2.22e-12
R04 N03 N04 1.18e+01
C05 N04 N05 3.21e-12
L05 N04 N05 2.43e-12
R05 N04 N05 1.22e+01
C06 N05 N06 1.96e-12
L06 N05 N06 3.58e-12
R06 N05 N06 2.16e+01
C07 N06 N07 2.20e-13
L07 N06 N07 2.45e-11
R07 N06 N07 3.42e+02
C08 N07 Port2 7.40e-13
L08 N07 Port2 7.28e-12
R08 N07 Port2 5.89e+01
.ENDS GJM0225C1ER70WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.10e-06[uF]/25[V]
* Murata P/N :GJM0225C1E1R1CB01
* Property : C = 1.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E1R1CB01 Port1 Port2
C01 Port1 N01 1.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 2.90e-01
L04 N03 N04 2.91e-12
R04 N03 N04 9.15e+00
C05 N04 N05 1.18e-11
L05 N04 N05 2.09e-12
R05 N04 N05 7.33e+00
C06 N05 N06 1.08e-11
L06 N05 N06 1.92e-12
R06 N05 N06 7.16e+00
C07 N06 N07 1.02e-10
L07 N06 N07 1.65e-13
R07 N06 N07 1.46e+00
C08 N07 Port2 1.73e-12
L08 N07 Port2 7.73e-12
R08 N07 Port2 2.66e+01
.ENDS GJM0225C1E1R1CB01

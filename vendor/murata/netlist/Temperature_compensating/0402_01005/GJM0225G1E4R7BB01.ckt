*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/4.70e-06[uF]/25[V]
* Murata P/N :GJM0225G1E4R7BB01
* Property : C = 4.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E4R7BB01 Port1 Port2
C01 Port1 N01 4.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.47e-01
L04 N03 N04 9.14e-13
R04 N03 N04 3.08e-02
C05 N04 N05 6.92e-11
L05 N04 N05 1.67e-12
R05 N04 N05 2.27e+00
C06 N05 N06 1.26e-10
L06 N05 N06 6.93e-13
R06 N05 N06 1.91e-01
C07 N06 N07 8.68e-12
L07 N06 N07 5.80e-12
R07 N06 N07 1.03e+01
C08 N07 N08 5.08e-11
L08 N07 N08 5.52e-13
R08 N07 N08 8.35e-01
C09 N08 N09 1.16e-11
L09 N08 N09 1.82e-12
R09 N08 N09 3.56e+00
C10 N09 N10 3.46e-11
L10 N09 N10 4.51e-13
R10 N09 N10 8.16e-01
C11 N10 Port2 1.84e-12
L11 N10 Port2 5.50e-12
R11 N10 Port2 1.34e+01
.ENDS GJM0225G1E4R7BB01

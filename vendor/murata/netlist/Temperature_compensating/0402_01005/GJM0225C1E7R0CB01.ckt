*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/7.00e-06[uF]/25[V]
* Murata P/N :GJM0225C1E7R0CB01
* Property : C = 7.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E7R0CB01 Port1 Port2
C01 Port1 N01 7.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 1.30e-01
L04 N03 N04 2.58e-12
R04 N03 N04 2.68e-02
C05 N04 N05 1.42e-10
L05 N04 N05 1.04e-12
R05 N04 N05 1.14e+00
C06 N05 N06 1.07e-10
L06 N05 N06 7.09e-13
R06 N05 N06 2.09e-01
C07 N06 N07 1.09e-11
L07 N06 N07 5.27e-12
R07 N06 N07 8.21e+00
C08 N07 N08 8.35e-11
L08 N07 N08 3.45e-13
R08 N07 N08 6.48e-01
C09 N08 N09 7.56e-11
L09 N08 N09 3.12e-13
R09 N08 N09 4.70e-01
C10 N09 N10 1.14e-11
L10 N09 N10 1.63e-12
R10 N09 N10 4.59e+00
C11 N10 Port2 4.60e-12
L11 N10 Port2 2.08e-12
R11 N10 Port2 6.13e+00
.ENDS GJM0225C1E7R0CB01

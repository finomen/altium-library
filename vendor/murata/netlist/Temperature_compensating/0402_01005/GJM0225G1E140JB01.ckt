*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.40e-05[uF]/25[V]
* Murata P/N :GJM0225G1E140JB01
* Property : C = 1.40e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E140JB01 Port1 Port2
C01 Port1 N01 1.40e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 7.98e-02
L04 N03 N04 6.28e-12
R04 N03 N04 7.89e-02
C05 N04 N05 3.15e-10
L05 N04 N05 1.12e-12
R05 N04 N05 8.45e-01
C06 N05 N06 2.53e-11
L06 N05 N06 5.81e-12
R06 N05 N06 4.81e+00
C07 N06 N07 2.48e-10
L07 N06 N07 2.92e-13
R07 N06 N07 2.71e-01
C08 N07 N08 3.15e-11
L08 N07 N08 1.49e-12
R08 N07 N08 1.96e+00
C09 N08 Port2 2.93e-11
L09 N08 Port2 9.45e-13
R09 N08 Port2 1.24e+00
.ENDS GJM0225G1E140JB01

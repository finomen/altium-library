*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/4.10e-06[uF]/25[V]
* Murata P/N :GJM0225G1E4R1WB01
* Property : C = 4.10e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E4R1WB01 Port1 Port2
C01 Port1 N01 4.10e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.60e-01
L04 N03 N04 5.26e-13
R04 N03 N04 1.48e-02
C05 N04 N05 7.52e-11
L05 N04 N05 1.20e-12
R05 N04 N05 1.77e+00
C06 N05 N06 1.26e-10
L06 N05 N06 6.93e-13
R06 N05 N06 1.91e-01
C07 N06 N07 7.99e-12
L07 N06 N07 4.87e-12
R07 N06 N07 9.42e+00
C08 N07 N08 1.30e-11
L08 N07 N08 1.35e-12
R08 N07 N08 2.96e+00
C09 N08 Port2 2.85e-12
L09 N08 Port2 3.09e-12
R09 N08 Port2 1.09e+01
.ENDS GJM0225G1E4R1WB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.20e-05[uF]/25[V]
* Murata P/N :GJM0225G1E120GB01
* Property : C = 1.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E120GB01 Port1 Port2
C01 Port1 N01 1.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 8.11e-02
L04 N03 N04 2.30e-12
R04 N03 N04 7.68e-02
L05 N04 N05 9.36e-12
R05 N04 N05 5.94e-02
C06 N05 N06 2.46e-10
L06 N05 N06 1.22e-12
R06 N05 N06 8.88e-01
C07 N06 N07 2.16e-11
L07 N06 N07 5.83e-12
R07 N06 N07 4.99e+00
C08 N07 N08 2.54e-10
L08 N07 N08 2.49e-13
R08 N07 N08 2.94e-01
C09 N08 N09 2.38e-11
L09 N08 N09 1.75e-12
R09 N08 N09 2.23e+00
C10 N09 Port2 2.52e-11
L10 N09 Port2 1.15e-12
R10 N09 Port2 1.54e+00
.ENDS GJM0225G1E120GB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/3.80e-06[uF]/25[V]
* Murata P/N :GJM0225G1E3R8CB01
* Property : C = 3.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E3R8CB01 Port1 Port2
C01 Port1 N01 3.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.44e-10
R03 N02 N03 1.80e-01
L04 N03 N04 6.29e-13
R04 N03 N04 2.32e-02
C05 N04 N05 6.48e-11
L05 N04 N05 1.40e-12
R05 N04 N05 2.22e+00
C06 N05 N06 1.18e-10
L06 N05 N06 5.32e-13
R06 N05 N06 4.14e-01
C07 N06 N07 7.41e-12
L07 N06 N07 5.30e-12
R07 N06 N07 1.28e+01
C08 N07 N08 4.16e-12
L08 N07 N08 4.50e-12
R08 N07 N08 8.65e+00
C09 N08 Port2 3.05e-12
L09 N08 Port2 4.55e-12
R09 N08 Port2 1.57e+01
.ENDS GJM0225G1E3R8CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.50e-06[uF]/16[V]
* Murata P/N :GJM0225C1C2R5WB01
* Property : C = 2.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C2R5WB01 Port1 Port2
C01 Port1 N01 2.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.64e-10
R03 N02 N03 2.14e-01
L04 N03 N04 4.88e-13
R04 N03 N04 1.61e-02
C05 N04 N05 8.16e-11
L05 N04 N05 6.00e-13
R05 N04 N05 1.42e+00
C06 N05 N06 2.23e-12
L06 N05 N06 9.87e-12
R06 N05 N06 2.36e+01
C07 N06 Port2 4.47e-12
L07 N06 Port2 2.99e-12
R07 N06 Port2 5.54e+00
.ENDS GJM0225C1C2R5WB01

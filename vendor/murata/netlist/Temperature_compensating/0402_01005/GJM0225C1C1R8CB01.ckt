*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.80e-06[uF]/16[V]
* Murata P/N :GJM0225C1C1R8CB01
* Property : C = 1.80e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C1R8CB01 Port1 Port2
C01 Port1 N01 1.80e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 2.03e-01
L04 N03 N04 7.72e-13
R04 N03 N04 2.42e-02
C05 N04 N05 2.65e-11
L05 N04 N05 1.73e-12
R05 N04 N05 5.99e+00
C06 N05 N06 6.84e-11
L06 N05 N06 4.31e-13
R06 N05 N06 3.63e-01
C07 N06 N07 4.89e-12
L07 N06 N07 4.45e-12
R07 N06 N07 1.82e+01
C08 N07 Port2 2.64e-12
L08 N07 Port2 4.58e-12
R08 N07 Port2 9.11e+00
.ENDS GJM0225C1C1R8CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.40e-06[uF]/25[V]
* Murata P/N :GJM0225G1E1R4CB01
* Property : C = 1.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E1R4CB01 Port1 Port2
C01 Port1 N01 1.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 2.61e-01
C04 N03 N04 1.32e-11
L04 N03 N04 2.55e-12
R04 N03 N04 7.83e+00
C05 N04 N05 2.36e-10
L05 N04 N05 8.71e-14
R05 N04 N05 9.86e-01
C06 N05 N06 2.13e-12
L06 N05 N06 7.53e-12
R06 N05 N06 2.59e+01
C07 N06 N07 3.73e-12
L07 N06 N07 3.15e-12
R07 N06 N07 1.06e+01
C08 N07 Port2 5.24e-12
L08 N07 Port2 2.03e-12
R08 N07 Port2 1.24e+01
.ENDS GJM0225G1E1R4CB01

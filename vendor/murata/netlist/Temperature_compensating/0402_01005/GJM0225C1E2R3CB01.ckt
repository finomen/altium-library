*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.30e-06[uF]/25[V]
* Murata P/N :GJM0225C1E2R3CB01
* Property : C = 2.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E2R3CB01 Port1 Port2
C01 Port1 N01 2.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.35e-10
R03 N02 N03 1.85e-01
L04 N03 N04 5.61e-13
R04 N03 N04 2.17e-02
C05 N04 N05 3.75e-11
L05 N04 N05 1.56e-12
R05 N04 N05 4.16e+00
C06 N05 N06 3.47e-12
L06 N05 N06 7.93e-12
R06 N05 N06 2.39e+01
C07 N06 N07 6.97e-12
L07 N06 N07 2.90e-12
R07 N06 N07 5.74e+00
C08 N07 N08 1.25e-11
L08 N07 N08 1.31e-12
R08 N07 N08 4.07e+00
C09 N08 Port2 1.61e-12
L09 N08 Port2 6.70e-12
R09 N08 Port2 2.88e+01
.ENDS GJM0225C1E2R3CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/9.70e-06[uF]/25[V]
* Murata P/N :GJM0225C1E9R7CB01
* Property : C = 9.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E9R7CB01 Port1 Port2
C01 Port1 N01 9.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.49e-10
R03 N02 N03 8.50e-02
L04 N03 N04 6.41e-12
R04 N03 N04 5.55e-02
C05 N04 N05 9.99e-11
L05 N04 N05 2.26e-12
R05 N04 N05 2.20e+00
C06 N05 N06 1.57e-11
L06 N05 N06 5.75e-12
R06 N05 N06 7.29e+00
C07 N06 N07 1.36e-10
L07 N06 N07 3.30e-13
R07 N06 N07 5.40e-01
C08 N07 N08 9.50e-12
L08 N07 N08 3.04e-12
R08 N07 N08 5.92e+00
C09 N08 Port2 3.55e-12
L09 N08 Port2 3.94e-12
R09 N08 Port2 1.42e+01
.ENDS GJM0225C1E9R7CB01

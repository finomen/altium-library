*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/3.60e-06[uF]/25[V]
* Murata P/N :GJM0225G1E3R6BB01
* Property : C = 3.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E3R6BB01 Port1 Port2
C01 Port1 N01 3.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.50e-10
R03 N02 N03 1.90e-01
L04 N03 N04 2.94e-13
R04 N03 N04 1.09e-02
C05 N04 N05 6.86e-11
L05 N04 N05 1.09e-12
R05 N04 N05 1.96e+00
C06 N05 N06 5.90e-12
L06 N05 N06 5.41e-12
R06 N05 N06 1.26e+01
C07 N06 N07 3.22e-12
L07 N06 N07 6.17e-12
R07 N06 N07 1.38e+01
C08 N07 Port2 5.13e-12
L08 N07 Port2 2.69e-12
R08 N07 Port2 9.77e+00
.ENDS GJM0225G1E3R6BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/8.90e-06[uF]/16[V]
* Murata P/N :GJM0225C1C8R9BB01
* Property : C = 8.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C8R9BB01 Port1 Port2
C01 Port1 N01 8.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 8.50e-02
L04 N03 N04 6.71e-12
R04 N03 N04 5.81e-02
C05 N04 N05 9.46e-11
L05 N04 N05 2.19e-12
R05 N04 N05 2.20e+00
C06 N05 N06 1.37e-11
L06 N05 N06 6.07e-12
R06 N05 N06 8.18e+00
C07 N06 N07 2.03e-10
L07 N06 N07 2.05e-13
R07 N06 N07 4.81e-01
C08 N07 N08 1.18e-11
L08 N07 N08 2.27e-12
R08 N07 N08 4.93e+00
C09 N08 Port2 6.69e-12
L09 N08 Port2 2.04e-12
R09 N08 Port2 7.46e+00
.ENDS GJM0225C1C8R9BB01

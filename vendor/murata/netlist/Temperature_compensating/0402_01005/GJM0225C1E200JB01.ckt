*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.00e-05[uF]/25[V]
* Murata P/N :GJM0225C1E200JB01
* Property : C = 2.00e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E200JB01 Port1 Port2
C01 Port1 N01 2.00e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.48e-10
R03 N02 N03 5.66e-02
L04 N03 N04 6.95e-12
R04 N03 N04 1.17e-01
C05 N04 N05 3.18e-10
L05 N04 N05 1.69e-12
R05 N04 N05 1.07e+00
C06 N05 N06 3.74e-11
L06 N05 N06 6.26e-12
R06 N05 N06 4.47e+00
C07 N06 N07 2.10e-10
L07 N06 N07 5.58e-13
R07 N06 N07 3.55e-01
C08 N07 N08 4.30e-11
L08 N07 N08 1.80e-12
R08 N07 N08 1.78e+00
C09 N08 N09 4.40e-11
L09 N08 N09 9.05e-13
R09 N08 N09 1.10e+00
C10 N09 Port2 1.50e-11
L10 N09 Port2 1.78e-12
R10 N09 Port2 1.86e+00
.ENDS GJM0225C1E200JB01

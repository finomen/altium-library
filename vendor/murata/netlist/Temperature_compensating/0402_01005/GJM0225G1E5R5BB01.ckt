*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/5.50e-06[uF]/25[V]
* Murata P/N :GJM0225G1E5R5BB01
* Property : C = 5.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E5R5BB01 Port1 Port2
C01 Port1 N01 5.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.47e-01
L04 N03 N04 6.78e-13
R04 N03 N04 2.75e-02
C05 N04 N05 8.43e-11
L05 N04 N05 1.54e-12
R05 N04 N05 1.98e+00
C06 N05 N06 1.26e-10
L06 N05 N06 6.93e-13
R06 N05 N06 1.91e-01
C07 N06 N07 1.03e-11
L07 N06 N07 5.49e-12
R07 N06 N07 9.00e+00
C08 N07 N08 4.37e-11
L08 N07 N08 7.19e-13
R08 N07 N08 1.03e+00
C09 N08 N09 1.43e-11
L09 N08 N09 1.63e-12
R09 N08 N09 3.25e+00
C10 N09 N10 2.03e-11
L10 N09 N10 8.40e-13
R10 N09 N10 1.45e+00
C11 N10 Port2 3.67e-12
L11 N10 Port2 2.76e-12
R11 N10 Port2 1.34e+01
.ENDS GJM0225G1E5R5BB01

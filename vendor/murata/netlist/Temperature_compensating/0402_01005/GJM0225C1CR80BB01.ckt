*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/8.00e-07[uF]/16[V]
* Murata P/N :GJM0225C1CR80BB01
* Property : C = 8.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1CR80BB01 Port1 Port2
C01 Port1 N01 8.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.32e-10
R03 N02 N03 2.38e-01
C04 N03 N04 8.81e-12
L04 N03 N04 2.36e-12
R04 N03 N04 1.48e+01
C05 N04 N05 1.85e-12
L05 N04 N05 6.39e-12
R05 N04 N05 2.94e+01
C06 N05 N06 1.96e-12
L06 N05 N06 3.58e-12
R06 N05 N06 2.16e+01
C07 N06 Port2 8.30e-13
L07 N06 Port2 8.17e-12
R07 N06 Port2 5.89e+01
.ENDS GJM0225C1CR80BB01

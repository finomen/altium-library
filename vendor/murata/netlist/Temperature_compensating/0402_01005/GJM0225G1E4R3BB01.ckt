*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/4.30e-06[uF]/25[V]
* Murata P/N :GJM0225G1E4R3BB01
* Property : C = 4.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E4R3BB01 Port1 Port2
C01 Port1 N01 4.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.47e-10
R03 N02 N03 1.60e-01
L04 N03 N04 5.03e-13
R04 N03 N04 1.41e-02
C05 N04 N05 8.64e-11
L05 N04 N05 1.09e-12
R05 N04 N05 1.57e+00
C06 N05 N06 1.26e-10
L06 N05 N06 6.93e-13
R06 N05 N06 1.91e-01
C07 N06 N07 7.85e-12
L07 N06 N07 5.25e-12
R07 N06 N07 1.03e+01
C08 N07 N08 1.15e-11
L08 N07 N08 1.57e-12
R08 N07 N08 3.40e+00
C09 N08 Port2 3.27e-12
L09 N08 Port2 3.09e-12
R09 N08 Port2 9.50e+00
.ENDS GJM0225G1E4R3BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/3.40e-06[uF]/16[V]
* Murata P/N :GJM0225C1C3R4CB01
* Property : C = 3.40e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C3R4CB01 Port1 Port2
C01 Port1 N01 3.40e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 1.97e-01
C04 N03 N04 5.63e-11
L04 N03 N04 1.21e-12
R04 N03 N04 1.94e+00
C05 N04 N05 5.39e-12
L05 N04 N05 5.56e-12
R05 N04 N05 1.28e+01
C06 N05 N06 5.88e-12
L06 N05 N06 3.33e-12
R06 N05 N06 6.41e+00
C07 N06 Port2 6.50e-12
L07 N06 Port2 2.12e-12
R07 N06 Port2 7.70e+00
.ENDS GJM0225C1C3R4CB01

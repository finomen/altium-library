*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.60e-06[uF]/16[V]
* Murata P/N :GJM0225C1C1R6WB01
* Property : C = 1.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C1R6WB01 Port1 Port2
C01 Port1 N01 1.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.45e-10
R03 N02 N03 2.33e-01
L04 N03 N04 3.91e-13
R04 N03 N04 2.45e-02
C05 N04 N05 1.64e-11
L05 N04 N05 2.32e-12
R05 N04 N05 7.01e+00
C06 N05 N06 4.34e-10
L06 N05 N06 7.07e-14
R06 N05 N06 2.99e-01
C07 N06 N07 2.55e-12
L07 N06 N07 7.22e-12
R07 N06 N07 2.73e+01
C08 N07 N08 1.42e-12
L08 N07 N08 8.78e-12
R08 N07 N08 2.02e+01
C09 N08 Port2 2.33e-12
L09 N08 Port2 4.36e-12
R09 N08 Port2 2.38e+01
.ENDS GJM0225C1C1R6WB01

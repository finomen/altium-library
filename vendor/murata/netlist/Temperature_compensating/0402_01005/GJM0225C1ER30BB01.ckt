*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/3.00e-07[uF]/25[V]
* Murata P/N :GJM0225C1ER30BB01
* Property : C = 3.00e-07[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1ER30BB01 Port1 Port2
C01 Port1 N01 3.00e-13
R01 Port1 N01 1.00e+10
L02 N01 N02 1.34e-10
R03 N02 N03 2.99e-01
C04 N03 N04 2.10e-12
L04 N03 N04 3.49e-12
R04 N03 N04 1.55e+01
C05 N04 N05 5.74e-13
L05 N04 N05 9.44e-12
R05 N04 N05 8.35e+01
C06 N05 Port2 2.24e-13
L06 N05 Port2 2.10e-11
R06 N05 Port2 3.23e+02
.ENDS GJM0225C1ER30BB01

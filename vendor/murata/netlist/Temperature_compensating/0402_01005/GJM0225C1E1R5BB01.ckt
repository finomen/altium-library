*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.50e-06[uF]/25[V]
* Murata P/N :GJM0225C1E1R5BB01
* Property : C = 1.50e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E1R5BB01 Port1 Port2
C01 Port1 N01 1.50e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 2.48e-01
C04 N03 N04 1.99e-11
L04 N03 N04 1.91e-12
R04 N03 N04 6.33e+00
C05 N04 N05 4.45e-12
L05 N04 N05 4.92e-12
R05 N04 N05 9.37e+00
C06 N05 N06 4.47e-12
L06 N05 N06 4.10e-12
R06 N05 N06 1.70e+01
C07 N06 N07 2.86e-12
L07 N06 N07 4.36e-12
R07 N06 N07 9.37e+00
C08 N07 Port2 8.56e-12
L08 N07 Port2 1.19e-12
R08 N07 Port2 8.54e+00
.ENDS GJM0225C1E1R5BB01

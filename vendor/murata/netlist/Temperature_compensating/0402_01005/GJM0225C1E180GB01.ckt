*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.80e-05[uF]/25[V]
* Murata P/N :GJM0225C1E180GB01
* Property : C = 1.80e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E180GB01 Port1 Port2
C01 Port1 N01 1.80e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.55e-10
R03 N02 N03 6.16e-02
L04 N03 N04 6.30e-12
R04 N03 N04 1.10e-01
C05 N04 N05 3.25e-10
L05 N04 N05 1.48e-12
R05 N04 N05 9.08e-01
C06 N05 N06 3.39e-11
L06 N05 N06 6.08e-12
R06 N05 N06 4.45e+00
C07 N06 N07 2.50e-10
L07 N06 N07 4.34e-13
R07 N06 N07 2.94e-01
C08 N07 N08 4.23e-11
L08 N07 N08 1.63e-12
R08 N07 N08 1.77e+00
C09 N08 N09 2.72e-11
L09 N08 N09 1.35e-12
R09 N08 N09 1.04e+00
C10 N09 Port2 3.36e-11
L10 N09 Port2 8.53e-13
R10 N09 Port2 1.17e+00
.ENDS GJM0225C1E180GB01

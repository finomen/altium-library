*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.90e-06[uF]/16[V]
* Murata P/N :GJM0225C1C1R9CB01
* Property : C = 1.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C1R9CB01 Port1 Port2
C01 Port1 N01 1.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.40e-10
R03 N02 N03 1.95e-01
L04 N03 N04 7.69e-13
R04 N03 N04 3.41e-02
C05 N04 N05 3.00e-11
L05 N04 N05 1.56e-12
R05 N04 N05 5.10e+00
C06 N05 N06 2.50e-12
L06 N05 N06 9.00e-12
R06 N05 N06 2.94e+01
C07 N06 Port2 2.54e-12
L07 N06 Port2 4.79e-12
R07 N06 Port2 9.95e+00
.ENDS GJM0225C1C1R9CB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/7.30e-06[uF]/25[V]
* Murata P/N :GJM0225G1E7R3CB01
* Property : C = 7.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E7R3CB01 Port1 Port2
C01 Port1 N01 7.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.54e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.24e-12
R04 N03 N04 1.30e-01
C05 N04 N05 1.31e-10
L05 N04 N05 1.15e-12
R05 N04 N05 1.49e+00
C06 N05 N06 1.17e-11
L06 N05 N06 5.16e-12
R06 N05 N06 8.35e+00
C07 N06 N07 5.17e-11
L07 N06 N07 5.71e-13
R07 N06 N07 7.62e-01
C08 N07 N08 1.41e-11
L08 N07 N08 1.36e-12
R08 N07 N08 3.56e+00
C09 N08 Port2 5.03e-11
L09 N08 Port2 2.66e-13
R09 N08 Port2 1.24e+00
.ENDS GJM0225G1E7R3CB01

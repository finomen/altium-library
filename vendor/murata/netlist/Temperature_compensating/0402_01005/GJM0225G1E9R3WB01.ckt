*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/9.30e-06[uF]/25[V]
* Murata P/N :GJM0225G1E9R3WB01
* Property : C = 9.30e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E9R3WB01 Port1 Port2
C01 Port1 N01 9.30e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.56e-10
R03 N02 N03 8.50e-02
L04 N03 N04 6.71e-12
R04 N03 N04 5.81e-02
C05 N04 N05 1.21e-10
L05 N04 N05 1.81e-12
R05 N04 N05 1.75e+00
C06 N05 N06 1.77e-11
L06 N05 N06 4.93e-12
R06 N05 N06 6.35e+00
C07 N06 N07 2.55e-10
L07 N06 N07 1.63e-13
R07 N06 N07 3.82e-01
C08 N07 N08 1.87e-11
L08 N07 N08 1.50e-12
R08 N07 N08 2.97e+00
C09 N08 Port2 9.34e-12
L09 N08 Port2 1.50e-12
R09 N08 Port2 5.40e+00
.ENDS GJM0225G1E9R3WB01

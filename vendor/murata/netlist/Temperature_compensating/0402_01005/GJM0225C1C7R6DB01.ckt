*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/7.60e-06[uF]/16[V]
* Murata P/N :GJM0225C1C7R6DB01
* Property : C = 7.60e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C7R6DB01 Port1 Port2
C01 Port1 N01 7.60e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 9.50e-02
L04 N03 N04 4.34e-12
R04 N03 N04 1.19e-01
C05 N04 N05 1.40e-10
L05 N04 N05 1.16e-12
R05 N04 N05 1.44e+00
C06 N05 N06 1.27e-11
L06 N05 N06 5.02e-12
R06 N05 N06 7.55e+00
C07 N06 N07 6.04e-11
L07 N06 N07 4.98e-13
R07 N06 N07 6.43e-01
C08 N07 N08 1.37e-11
L08 N07 N08 1.49e-12
R08 N07 N08 4.25e+00
C09 N08 N09 8.65e-11
L09 N08 N09 1.96e-13
R09 N08 N09 8.47e-01
C10 N09 Port2 7.69e-11
L10 N09 Port2 1.75e-13
R10 N09 Port2 9.08e-01
.ENDS GJM0225C1C7R6DB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.20e-06[uF]/25[V]
* Murata P/N :GJM0225C1E1R2BB01
* Property : C = 1.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E1R2BB01 Port1 Port2
C01 Port1 N01 1.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.69e-10
R03 N02 N03 2.90e-01
L04 N03 N04 2.66e-13
R04 N03 N04 5.40e-02
C05 N04 N05 2.06e-11
L05 N04 N05 1.39e-12
R05 N04 N05 3.93e+00
C06 N05 N06 2.97e-11
L06 N05 N06 6.95e-13
R06 N05 N06 3.05e+00
C07 N06 Port2 2.17e-12
L07 N06 Port2 7.00e-12
R07 N06 Port2 1.97e+01
.ENDS GJM0225C1E1R2BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/2.20e-05[uF]/25[V]
* Murata P/N :GJM0225G1E220GB01
* Property : C = 2.20e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E220GB01 Port1 Port2
C01 Port1 N01 2.20e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.42e-10
R03 N02 N03 5.53e-02
L04 N03 N04 1.01e-11
R04 N03 N04 6.92e-02
C05 N04 N05 2.96e-10
L05 N04 N05 2.05e-12
R05 N04 N05 1.24e+00
C06 N05 N06 3.95e-11
L06 N05 N06 6.67e-12
R06 N05 N06 4.64e+00
C07 N06 N07 1.84e-10
L07 N06 N07 7.30e-13
R07 N06 N07 4.53e-01
C08 N07 N08 4.27e-11
L08 N07 N08 2.03e-12
R08 N07 N08 1.93e+00
C09 N08 N09 4.28e-11
L09 N08 N09 1.01e-12
R09 N08 N09 1.34e+00
C10 N09 Port2 7.35e-12
L10 N09 Port2 3.40e-12
R10 N09 Port2 3.60e+00
.ENDS GJM0225G1E220GB01

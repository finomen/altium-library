*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/6.20e-06[uF]/16[V]
* Murata P/N :GJM0225C1C6R2CB01
* Property : C = 6.20e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C6R2CB01 Port1 Port2
C01 Port1 N01 6.20e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 1.20e-01
L04 N03 N04 4.58e-12
R04 N03 N04 5.61e-02
C05 N04 N05 1.42e-10
L05 N04 N05 9.02e-13
R05 N04 N05 1.04e+00
C06 N05 N06 1.05e-10
L06 N05 N06 6.93e-13
R06 N05 N06 2.09e-01
C07 N06 N07 1.13e-11
L07 N06 N07 4.34e-12
R07 N06 N07 7.66e+00
C08 N07 N08 9.87e-11
L08 N07 N08 2.95e-13
R08 N07 N08 3.03e-01
C09 N08 N09 6.74e-11
L09 N08 N09 3.67e-13
R09 N08 N09 6.79e-01
C10 N09 N10 1.13e-11
L10 N09 N10 1.41e-12
R10 N09 N10 3.65e+00
C11 N10 Port2 1.73e-11
L11 N10 Port2 5.95e-13
R11 N10 Port2 2.13e+00
.ENDS GJM0225C1C6R2CB01

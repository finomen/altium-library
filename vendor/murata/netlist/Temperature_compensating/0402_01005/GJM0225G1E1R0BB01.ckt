*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X8G(-55to150[deg])/1.00e-06[uF]/25[V]
* Murata P/N :GJM0225G1E1R0BB01
* Property : C = 1.00e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225G1E1R0BB01 Port1 Port2
C01 Port1 N01 1.00e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.61e-10
R03 N02 N03 3.15e-01
C04 N03 N04 3.38e-11
L04 N03 N04 6.56e-13
R04 N03 N04 2.69e+00
C05 N04 N05 2.98e-12
L05 N04 N05 4.11e-12
R05 N04 N05 1.61e+01
C06 N05 Port2 1.30e-12
L06 N05 Port2 5.94e-12
R06 N05 Port2 3.42e+01
.ENDS GJM0225G1E1R0BB01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/1.30e-05[uF]/25[V]
* Murata P/N :GJM0225C1E130JB01
* Property : C = 1.30e-05[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E130JB01 Port1 Port2
C01 Port1 N01 1.30e-11
R01 Port1 N01 1.00e+10
L02 N01 N02 1.58e-10
R03 N02 N03 8.01e-02
L04 N03 N04 5.48e-12
R04 N03 N04 1.27e-01
C05 N04 N05 2.42e-10
L05 N04 N05 1.35e-12
R05 N04 N05 9.38e-01
C06 N05 N06 1.99e-11
L06 N05 N06 6.99e-12
R06 N05 N06 5.20e+00
C07 N06 N07 1.38e-10
L07 N06 N07 5.24e-13
R07 N06 N07 5.34e-01
C08 N07 N08 3.73e-11
L08 N07 N08 1.27e-12
R08 N07 N08 1.47e+00
C09 N08 Port2 9.18e-12
L09 N08 Port2 3.00e-12
R09 N08 Port2 3.29e+00
.ENDS GJM0225C1E130JB01

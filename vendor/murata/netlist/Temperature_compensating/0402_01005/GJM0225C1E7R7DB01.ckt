*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/7.70e-06[uF]/25[V]
* Murata P/N :GJM0225C1E7R7DB01
* Property : C = 7.70e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1E7R7DB01 Port1 Port2
C01 Port1 N01 7.70e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.57e-10
R03 N02 N03 9.00e-02
L04 N03 N04 4.34e-12
R04 N03 N04 9.64e-02
C05 N04 N05 1.31e-10
L05 N04 N05 1.28e-12
R05 N04 N05 1.50e+00
C06 N05 N06 1.12e-11
L06 N05 N06 6.01e-12
R06 N05 N06 8.42e+00
C07 N06 N07 4.36e-11
L07 N06 N07 7.08e-13
R07 N06 N07 9.02e-01
C08 N07 N08 1.85e-11
L08 N07 N08 1.14e-12
R08 N07 N08 4.52e+00
C09 N08 N09 7.66e-11
L09 N08 N09 2.16e-13
R09 N08 N09 7.00e-01
C10 N09 Port2 2.87e-11
L10 N09 Port2 4.66e-13
R10 N09 Port2 1.43e+00
.ENDS GJM0225C1E7R7DB01

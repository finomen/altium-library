*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/C0G(-55to125[deg])/2.90e-06[uF]/16[V]
* Murata P/N :GJM0225C1C2R9CB01
* Property : C = 2.90e-06[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[MHz]-30[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GJM0225C1C2R9CB01 Port1 Port2
C01 Port1 N01 2.90e-12
R01 Port1 N01 1.00e+10
L02 N01 N02 1.59e-10
R03 N02 N03 2.13e-01
L04 N03 N04 1.86e-13
R04 N03 N04 6.85e-03
C05 N04 N05 4.16e-11
L05 N04 N05 1.42e-12
R05 N04 N05 2.27e+00
C06 N05 N06 4.44e-12
L06 N05 N06 6.01e-12
R06 N05 N06 1.43e+01
C07 N06 N07 1.98e-12
L07 N06 N07 1.02e-11
R07 N06 N07 2.02e+01
C08 N07 Port2 5.11e-12
L08 N07 Port2 2.63e-12
R08 N07 Port2 7.69e+00
.ENDS GJM0225C1C2R9CB01

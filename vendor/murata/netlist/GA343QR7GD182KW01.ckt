*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/1.80e-03[uF]/250[Vac]
* Murata P/N :GA343QR7GD182KW01
* Property : C = 1.80e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA343QR7GD182KW01 Port1 Port2
C01 Port1 N01 1.79e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 2.46e-10
R03 N02 N03 1.60e-01
C04 N03 N04 2.18e-08
R04 N03 N04 1.84e+02
C05 N04 N05 1.57e-07
R05 N04 N05 2.53e+00
C06 N05 N06 8.19e-08
R06 N05 N06 5.65e-01
C07 N06 N07 3.31e-08
R07 N06 N07 1.48e-01
L08 N07 N08 5.77e-11
R08 N07 N08 1.32e+00
C09 N08 N09 3.92e-09
L09 N08 N09 8.14e-11
R09 N08 N09 5.78e-01
C10 N09 N10 9.19e-10
L10 N09 N10 2.87e-11
R10 N09 N10 3.12e-01
C11 N10 Port2 7.10e-12
L11 N10 Port2 2.52e-10
R11 N10 Port2 2.50e+01
.ENDS GA343QR7GD182KW01

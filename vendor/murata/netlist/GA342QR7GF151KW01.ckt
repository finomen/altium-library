*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.50e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GF151KW01
* Property : C = 1.50e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GF151KW01 Port1 Port2
C01 Port1 N01 1.79e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 7.87e-14
R03 N02 N03 1.18e-01
C04 N03 N04 8.92e-10
R04 N03 N04 1.78e+03
C05 N04 N05 1.55e-08
R05 N04 N05 1.57e+01
C06 N05 N06 2.53e-08
R06 N05 N06 8.92e-01
C07 N06 N07 3.42e-09
R07 N06 N07 2.46e-01
L08 N07 N08 1.87e-10
R08 N07 N08 2.35e+00
C09 N08 N09 9.55e-10
L09 N08 N09 3.22e-11
R09 N08 N09 1.23e+00
C10 N09 N10 2.37e-10
L10 N09 N10 4.72e-11
R10 N09 N10 2.17e+00
C11 N10 Port2 1.23e-12
L11 N10 Port2 1.11e-09
R11 N10 Port2 2.76e+02
.ENDS GA342QR7GF151KW01

*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-03[uF]/250[Vac]
* Murata P/N :GA342DR7GF102KW02
* Property : C = 1.00e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342DR7GF102KW02 Port1 Port2
C01 Port1 N01 1.12e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 2.04e-10
R03 N02 N03 2.05e-01
C04 N03 N04 1.43e-08
R04 N03 N04 2.22e+02
C05 N04 N05 2.88e-07
R05 N04 N05 1.84e+00
C06 N05 N06 1.97e-07
R06 N05 N06 8.10e-01
C07 N06 N07 5.19e-08
R07 N06 N07 7.75e-01
C08 N07 N08 1.23e-08
R08 N07 N08 2.57e-01
L09 N08 N09 2.36e-10
R09 N08 N09 1.32e+00
C10 N09 N10 4.56e-09
L10 N09 N10 6.63e-11
R10 N09 N10 5.40e-01
C11 N10 N11 1.91e-09
L11 N10 N11 4.03e-11
R11 N10 N11 4.38e-01
C12 N11 Port2 2.11e-12
L12 N11 Port2 5.89e-10
R12 N11 Port2 7.34e+01
.ENDS GA342DR7GF102KW02

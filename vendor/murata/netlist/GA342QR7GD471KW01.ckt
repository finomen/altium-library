*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/4.70e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD471KW01
* Property : C = 4.70e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD471KW01 Port1 Port2
C01 Port1 N01 5.74e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.96e-10
R03 N02 N03 3.43e-01
C04 N03 N04 2.92e-09
R04 N03 N04 1.37e+03
C05 N04 N05 5.46e-08
R05 N04 N05 4.32e+00
C06 N05 N06 1.65e-08
R06 N05 N06 1.08e+00
C07 N06 N07 8.72e-08
R07 N06 N07 8.51e-01
C08 N07 N08 3.45e-09
R08 N07 N08 4.50e-01
C09 N08 N09 1.67e-09
L09 N08 N09 6.33e-11
R09 N08 N09 6.04e-01
C10 N09 N10 4.22e-10
L10 N09 N10 3.79e-11
R10 N09 N10 5.89e-01
C11 N10 Port2 2.42e-12
L11 N10 Port2 6.15e-10
R11 N10 Port2 4.02e+01
.ENDS GA342QR7GD471KW01

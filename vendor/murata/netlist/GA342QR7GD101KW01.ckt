*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD101KW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD101KW01 Port1 Port2
C01 Port1 N01 1.25e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 1.59e-10
R03 N02 N03 3.65e-01
C04 N03 N04 5.08e-10
R04 N03 N04 3.13e+03
C05 N04 N05 4.72e-09
R05 N04 N05 1.80e+02
C06 N05 N06 1.50e-08
R06 N05 N06 4.62e+00
C07 N06 N07 8.12e-09
R07 N06 N07 3.09e-01
L08 N07 N08 1.84e-10
R08 N07 N08 1.21e+01
C09 N08 N09 5.61e-10
L09 N08 N09 2.81e-11
R09 N08 N09 1.02e+00
C10 N09 N10 1.16e-10
L10 N09 N10 5.25e-11
R10 N09 N10 2.72e+00
C11 N10 Port2 1.51e-12
L11 N10 Port2 1.04e-09
R11 N10 Port2 3.03e+02
.ENDS GA342QR7GD101KW01

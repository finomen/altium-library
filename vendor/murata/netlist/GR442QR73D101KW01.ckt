*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/1.00e-04[uF]/2000[V]
* Murata P/N :GR442QR73D101KW01
* Property : C = 1.00e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 5[MHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR442QR73D101KW01 Port1 Port2
C01 Port1 N01 9.93e-11
R01 Port1 N01 6.00e+09
L02 N01 N02 2.04e-10
R03 N02 N03 3.00e-01
C04 N03 N04 5.65e-09
R04 N03 N04 8.76e+00
C05 N04 N05 4.88e-09
R05 N04 N05 2.92e-01
C06 N05 N06 8.21e-08
R06 N05 N06 4.70e-02
C07 N06 N07 5.38e-10
L07 N06 N07 2.94e-11
R07 N06 N07 1.09e+00
C08 N07 N08 6.30e-11
L08 N07 N08 8.47e-11
R08 N07 N08 3.91e+00
C09 N08 Port2 1.50e-12
L09 N08 Port2 1.06e-09
R09 N08 Port2 2.11e+02
.ENDS GR442QR73D101KW01

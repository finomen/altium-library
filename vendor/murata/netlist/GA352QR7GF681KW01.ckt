*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/6.80e-04[uF]/250[Vac]
* Murata P/N :GA352QR7GF681KW01
* Property : C = 6.80e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF681KW01 Port1 Port2
C01 Port1 N01 7.45e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.08e-10
R03 N02 N03 3.04e-01
C04 N03 N04 4.46e-09
R04 N03 N04 7.12e+02
C05 N04 N05 1.56e-07
R05 N04 N05 2.15e+00
C06 N05 N06 1.35e-07
R06 N05 N06 1.48e+00
C07 N06 N07 6.49e-08
R07 N06 N07 9.31e-01
C08 N07 N08 5.09e-08
R08 N07 N08 3.91e-01
C09 N08 N09 7.02e-09
R09 N08 N09 3.79e-01
L10 N09 N10 2.82e-10
R10 N09 N10 6.45e+00
C11 N10 N11 2.10e-09
L11 N10 N11 8.66e-11
R11 N10 N11 6.78e-01
C12 N11 N12 3.13e-09
L12 N11 N12 4.82e-12
R12 N11 N12 2.25e-01
C13 N12 Port2 4.40e-12
L13 N12 Port2 4.89e-10
R13 N12 Port2 5.31e+01
.ENDS GA352QR7GF681KW01

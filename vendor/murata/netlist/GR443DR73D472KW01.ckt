*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4532M(1812)/X7R(-55to125[deg])/4.70e-03[uF]/2000[V]
* Murata P/N :GR443DR73D472KW01
* Property : C = 4.70e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GR443DR73D472KW01 Port1 Port2
C01 Port1 N01 4.56e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 1.71e-11
R03 N02 N03 8.48e-02
C04 N03 N04 1.98e-07
R04 N03 N04 8.02e+00
C05 N04 N05 3.85e-07
R05 N04 N05 4.28e-01
C06 N05 N06 3.10e-07
R06 N05 N06 9.34e-02
C07 N06 N07 1.99e-07
R07 N06 N07 4.94e-02
L08 N07 N08 1.38e-10
R08 N07 N08 5.26e-01
C09 N08 N09 1.13e-08
L09 N08 N09 9.38e-11
R09 N08 N09 4.22e-01
C10 N09 N10 3.26e-09
L10 N09 N10 6.47e-11
R10 N09 N10 3.25e-01
C11 N10 N11 8.46e-12
L11 N10 N11 2.04e-10
R11 N10 N11 2.60e+01
C12 N11 Port2 3.07e-12
L12 N11 Port2 2.86e-10
R12 N11 Port2 3.36e+01
.ENDS GR443DR73D472KW01

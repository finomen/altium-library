*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5728M(2211)/X7R(-55to125[deg])/1.50e-03[uF]/250[Vac]
* Murata P/N :GA352QR7GF152KW01
* Property : C = 1.50e-03[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA352QR7GF152KW01 Port1 Port2
C01 Port1 N01 1.58e-09
R01 Port1 N01 6.00e+09
L02 N01 N02 2.29e-10
R03 N02 N03 1.52e-01
C04 N03 N04 2.10e-08
R04 N03 N04 1.51e+02
C05 N04 N05 1.83e-07
R05 N04 N05 2.18e+00
C06 N05 N06 1.40e-07
R06 N05 N06 5.68e-01
C07 N06 N07 9.37e-08
R07 N06 N07 2.12e-01
C08 N07 N08 1.91e-08
R08 N07 N08 1.66e-01
L09 N08 N09 1.85e-10
R09 N08 N09 9.32e-01
C10 N09 N10 3.63e-09
L10 N09 N10 8.35e-11
R10 N09 N10 5.31e-01
C11 N10 N11 1.37e-09
L11 N10 N11 4.97e-11
R11 N10 N11 4.14e-01
C12 N11 Port2 3.26e-12
L12 N11 Port2 5.49e-10
R12 N11 Port2 8.23e+01
.ENDS GA352QR7GF152KW01

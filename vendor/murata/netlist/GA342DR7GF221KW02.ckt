*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/2.20e-04[uF]/250[Vac]
* Murata P/N :GA342DR7GF221KW02
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342DR7GF221KW02 Port1 Port2
C01 Port1 N01 2.38e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.80e-10
R03 N02 N03 1.23e-01
C04 N03 N04 1.88e-09
R04 N03 N04 8.46e+02
C05 N04 N05 6.24e-08
R05 N04 N05 3.19e+00
C06 N05 N06 3.84e-08
R06 N05 N06 8.13e-01
C07 N06 N07 7.66e-09
R07 N06 N07 1.65e-01
L08 N07 N08 2.50e-10
R08 N07 N08 4.98e+00
C09 N08 N09 1.53e-09
L09 N08 N09 3.93e-11
R09 N08 N09 1.33e+00
C10 N09 N10 3.57e-10
L10 N09 N10 6.38e-11
R10 N09 N10 2.43e+00
C11 N10 Port2 1.75e-12
L11 N10 Port2 9.85e-10
R11 N10 Port2 1.37e+02
.ENDS GA342DR7GF221KW02

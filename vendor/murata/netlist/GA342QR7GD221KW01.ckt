*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :4520M(1808)/X7R(-55to125[deg])/2.20e-04[uF]/250[Vac]
* Murata P/N :GA342QR7GD221KW01
* Property : C = 2.20e-04[uF]
* Data Generated on Jan 30, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100[kHz]-3[GHz]
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GA342QR7GD221KW01 Port1 Port2
C01 Port1 N01 3.04e-10
R01 Port1 N01 6.00e+09
L02 N01 N02 2.78e-10
R03 N02 N03 6.12e-01
C04 N03 N04 7.81e-10
R04 N03 N04 5.12e+03
C05 N04 N05 3.12e-08
R05 N04 N05 1.70e+01
C06 N05 N06 1.32e-08
R06 N05 N06 3.90e+00
C07 N06 N07 5.95e-09
R07 N06 N07 1.34e+00
C08 N07 N08 1.92e-09
R08 N07 N08 6.64e-01
C09 N08 Port2 2.08e-12
L09 N08 Port2 7.16e-10
R09 N08 Port2 3.61e+01
.ENDS GA342QR7GD221KW01
